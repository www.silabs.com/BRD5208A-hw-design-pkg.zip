# Altium PCB PCB5208A_PA00.PcbDoc (part 4 of 5)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 115 x 60 mm, 6 copper layers (Top Layer, GND Layer 2, Signal Layer 3, Signal Layer 4, VCC Layer 5, Bottom Layer), stack 1.555 mm thick; 368 components, 246 nets, 1220 pads, 779 vias.

## Via types
v1: diameter 0.508, hole 0.25, Top Layer to Bottom Layer, tented both sides, 779 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
N16923003: R600.1 U600.7 | length 0.9
  Top Layer w0.25: U600.7@15.6,55.2 16.4,55.2 R600.1@16.5,55.3
N16923019: C602.1 U600.6 | length 0.9
  Top Layer w0.25: U600.6@15.6,54.7 C602.1@16.525,54.7
N16923678: C620.1 R682.2 U606.4 | length 3.5
  Top Layer w0.3: U606.4@26.25,24.725 26.25,24.85 26.675,25.275 27.975,25.275 28.075,25.175 R682.2@28.4,25.175 C620.1@28.4,26.2
N16923728: Q601.4 R628.1 R672.2 | length 1.8
  Top Layer w0.3: R628.1@23.35,26.875 R628.1@23.4,26.825 ; Q601.4@23.4,25.875 R628.1@23.4,26.825 ; R672.2@24.15,26.825 R628.1@23.4,26.825
N16923751: C654.1 R689.2 U622.4 | length 2.1
  Top Layer w0.1: R689.2@65.7,25.9 66.15,26.35 U622.4@66.55,26.35 66.65,26.35 67.025,26.725 C654.1@67.025,27.2
N16923761: Q605.1 R686.2 | length 1
  Top Layer w0.1: Q605.1@64.25,27.1 65.15,27.1 R686.2@65.25,27.2
N16923771: C653.1 R629.1 U622.3 | length 1.8
  Top Layer w0.1: U622.3@68.45,26.35 68.539,26.261 68.939,26.261 R629.1@69.3,25.9 C653.1@69.3,25.175
N16923785: Q605.2 R687.1 R688.1 R689.1 | length 5.4
  Top Layer w0.1: Q605.2@62.95,27.1 62.95,26 63.275,25.675 64.125,25.675 64.5,25.3 R688.1@65.1,25.3 R689.1@65.7,25.3
  Top Layer w0.4: R687.1@61.8,27.45 62.6,27.45 Q605.2@62.95,27.1
N16923803: C654.2 R686.1 U622.1 | length 4.8
  Top Layer w0.1: R686.1@66.15,27.2 66.475,27.525 67.25,27.525 C654.2@67.575,27.2 67.575,26.225 67.35,26 67.35,25.425 67.725,25.05 U622.1@68.45,25.05
N16923899: C652.1 R690.1 U622.5 | length 3.1
  Top Layer w0.1: R690.1@63.85,24.1 C652.1@64.9,24.1 65.55,24.75 66.15,24.75 66.45,25.05 U622.5@66.55,25.05
N16923917: C660.1 R681.1 U606.5 | length 8.2
  Top Layer w0.3: C660.1@25.05,24.675 25.675,24.05 26.875,24.05 U606.5@27.55,24.725 28.3,23.975 31.55,23.975 R681.1@32.15,24.575
N16923949: Q602.1 R679.2 | length 1.3
  Top Layer w0.3: Q602.1@29.2,25.875 30.05,26.725 R679.2@30.05,26.825
N16923963: C621.1 R672.1 U606.3 | length 4.2
  Top Layer w0.3: R672.1@24.15,26.225 C621.1@24.15,25.35 25.95,25.35 26.35,25.75 26.35,26.525 U606.3@26.25,26.625
N16923985: Q602.2 R674.1 R675.1 R682.1 | length 5.3
  Top Layer w0.3: R682.1@28.4,24.575 Q602.2@29.2,24.575 29.575,24.575 30.75,25.75 31.225,25.75 31.55,26.075 R674.1@31.55,26.625 32.2,26.625 R675.1@32.4,26.425
N16924018: C620.2 R679.1 U606.1 | length 1.7
  Top Layer w0.3: U606.1@27.55,26.625 27.675,26.75 C620.2@28.4,26.75 29.075,26.75 R679.1@29.15,26.825
N16924927: Q600.3 Q600.6 | length 4.3
  Top Layer w0.3: v1(19.95,25.875) Q600.6@20.45,25.875 ; v1(20.8,23.725) 21.15,23.725 21.45,24.025 Q600.3@21.45,24.575
  Signal Layer 4 w0.5: v1(19.95,25.875) 20.3,25.525 20.3,24.225 v1(20.8,23.725)
N16934878: C900.1 U900.J13 | length 1.7
  Top Layer w0.2: C900.1@42.05,45.975 42.15,45.875 42.575,45.875 42.743,45.707 43.039,45.707 43.246,45.5 U900.J13@43.6,45.5
N16934900: C903.1 C904.1 C905.1 C906.1 R130.2 U900.M9 U900.M10 U900.N11 | length 7.5
  Top Layer w0.2: 44.6,48.3 U900.N11@44.6,47.5 U900.M10@45.1,47 U900.M9@45.6,47
  Top Layer w0.3: 43.925,50.35 C906.1@43.925,49.9 C905.1@43.925,49.35 C904.1@43.925,48.8 44.1,48.8 44.6,48.3
  Top Layer w0.5: R130.2@40.95,50.4 C903.1@42.1,50.4 42.225,50.525 43.75,50.525 43.925,50.35
N16936696: U900.N10 X900.1 | length 1.7
  Top Layer w0.1: X900.1@45,49.1 44.9,49 44.9,47.7 U900.N10@45.1,47.5
N16936699: U900.N9 X900.3 | length 3.4
  Top Layer w0.1: U900.N9@45.6,47.5 45.55,47.5 45.225,47.825 45.225,48.3 45.6,48.675 45.6,49.4 X900.3@46.4,50.2
N16939106: TPJ909.1 U900.C11 | length 4.5
  Top Layer w0.1: v1(42.8,41.75) 42.873,41.677 42.902,41.677 43.475,42.25 44.35,42.25 U900.C11@44.6,42.5
  Bottom Layer w0.1: TPJ909.1@42.651,43.427 43.4,42.679 43.4,42.2 42.95,41.75 v1(42.8,41.75) v1@42.8,41.7
N16939109: TPJ910.1 U900.D11 | length 30.5
  Top Layer w0.1: v1(39.1,42.05) 39.45,42.4 40.625,42.4 40.925,42.7 41.725,42.7 42.275,43.25 43.714,43.25 43.85,43.114 43.85,42.886 43.986,42.75 44.35,42.75 U900.D11@44.6,43
  Signal Layer 3 w0.1: v1(37.45,30.5) 38.175,30.5 38.7,29.975 40.075,29.975 41.475,28.575 42.375,28.575 42.45,28.5 46.825,28.5 v1(47.225,28.9)
  Signal Layer 4 w0.1: v1(37.45,30.5) 37.45,40.4 v1(39.1,42.05)
  Bottom Layer w0.1: v1(47.225,28.9) 47.253,28.9 TPJ910.1@48.003,29.65
N16939489: TPJ911.1 U900.F11 | length 18.7
  Top Layer w0.1: U900.F11@44.6,44 45.825,44 v1(46.025,43.8)
  Signal Layer 4 w0.1: v1(46.025,43.8) 46.125,43.8 46.75,43.175 46.75,42.65 47.375,42.025 47.375,37.75 47.775,37.35 47.775,36.425 46.675,35.325 46.675,29.25 v1(46.35,28.925)
  Bottom Layer w0.1: TPJ911.1@45.453,28.85 45.528,28.925 v1(46.35,28.925)
N16939638: TPJ900.1 U900.A2 | length 15.8
  Top Layer w0.1: U900.A2@49.1,41.5 49.15,41.45 49.15,41.314 49.2,41.264 49.2,40.25 v1(49.65,39.8)
  Signal Layer 3 w0.1: v1(39.725,39.8) 40.025,40.1 41.4,40.1 41.525,40.225 44.2,40.225 45.275,41.3 48.15,41.3 v1(49.65,39.8)
  Bottom Layer w0.1: v1(39.725,39.8) 41.602,37.923 TPJ900.1@41.602,37.9
N16939640: TPJ901.1 U900.A1 | length 7.9
  Top Layer w0.1: U900.A1@49.6,41.5 49.6,40.85 v1(49.85,40.6)
  Bottom Layer w0.1: TPJ901.1@44.053,38.55 44.528,39.025 45,39.025 45.65,39.675 45.65,39.925 46.5,40.775 47.85,40.775 48.025,40.6 v1(49.85,40.6)
N16940103: TPJ908.1 U900.A9 | length 6.2
  Top Layer w0.1: v1(45.45,40.8) 45.45,41.1 45.6,41.25 U900.A9@45.6,41.5
  Bottom Layer w0.1: TPJ908.1@43.952,45.601 43.952,42.298 v1(45.45,40.8)
N16942491: R902.2 U900.B13 | length 2.1
  Top Layer w0.12: R902.2@42.1,41.75 42.6,41.25 42.95,41.25 43.34,41.64 43.34,41.74 U900.B13@43.6,42
N16942503: R904.2 U900.A13 | length 1.9
  Top Layer w0.12: R904.2@42.1,40.875 42.175,40.95 42.525,40.95 42.7,40.775 42.875,40.775 U900.A13@43.6,41.5
N16943456: TPJ902.1 U900.A8 | length 24.9
  Top Layer w0.1: v1(46.05,39.75) 46.1,39.8 U900.A8@46.1,41.5
  Signal Layer 3 w0.1: v1(25.5,41.4) 25.925,41.825 31.484,41.825 34.134,39.175 40.95,39.175 41.7,39.925 45,39.925 45.175,39.75 v1(46.05,39.75)
  Bottom Layer w0.1: TPJ902.1@24.551,41.351 TPJ902.1@24.6,41.4 v1(25.5,41.4)
N16944010: LED903.2 R912.2 | length 0.9
  Top Layer w0.2: LED903.2@20.05,47.6 20.15,47.5 20.15,46.85 R912.2@20.2,46.8
N16966205: LED904.2 R920.2 | length 0.9
  Top Layer w0.2: R920.2@18.9,49.75 LED904.2@19.85,49.75
N16966207: LED904.1 R919.2 | length 0.9
  Top Layer w0.2: R919.2@18.9,49.05 LED904.1@19.85,49.05
N16966211: LED901.1 R903.2 | length 0.9
  Top Layer w0.2: LED901.1@9.75,50.4 9.85,50.3 9.85,49.65 R903.2@9.9,49.6
N16966215: LED900.1 R900.2 | length 0.7
  Top Layer w0.3: R900.2@87.25,54.9 LED900.1@87.25,55.55
N16996446: Q807.5 Q807.6 R838.1 | length 2.1
  Top Layer w0.1: Q807.6@63.125,29 R838.1@62.175,29 62.675,29.5 Q807.5@63.125,29.5
N17012885: L900.2 R130.1 | length 1
  Top Layer w0.5: L900.2@39.065,50.4 R130.1@40.05,50.4
N17208223: P100.3 R145.1 R146.2 | length 11.2
  Top Layer w0.1: P100.3@46.25,30.175 46.25,29.625 46.775,29.1 46.775,28.475 48,27.25 49.15,27.25 50.175,28.275 50.175,29.025 51.55,30.4 R145.1@52.9,30.4 R146.2@53.775,30.4
N17208307: P100.10 TP150.1 U100.16 | length 15
  Top Layer w0.1: v1(39.3,32.25) 39.975,31.575 U100.16@39.975,31.375 ; v1(49.75,29.125) P100.10@49.75,30.175
  Signal Layer 3 w0.1: v1(39.3,32.25) 40.375,31.175 41.525,31.175 41.962,30.738 42.487,30.738 42.925,30.3 43.8,30.3 44.325,29.775 49.1,29.775 v1(49.75,29.125)
  Bottom Layer w0.1: TP150.1@38.3,32.3 39.25,32.3 v1(39.3,32.25)
N17208309: P100.9 TP151.1 U100.4 | length 16.7
  Top Layer w0.1: v1(38.3,28.775) 39.1,29.575 U100.4@39.775,29.575 ; v1(49.25,28.25) P100.9@49.25,30.175
  Signal Layer 3 w0.1: v1(38.3,28.775) 38.95,29.425 39.7,29.425 41.1,28.025 42.15,28.025 42.225,27.95 48.25,27.95 48.55,28.25 v1(49.25,28.25)
  Bottom Layer w0.1: TP151.1@38.3,27.8 v1(38.3,28.775)
N17208311: P100.8 TP152.1 U100.8 | length 12.3
  Top Layer w0.1: U100.8@41.175,28.975 41.175,28.025 v1(41.6,27.6) ; v1(48.75,27.725) P100.8@48.75,30.175
  Signal Layer 3 w0.1: v1(41.6,27.6) 41.675,27.675 v1@48.75,27.675
  Bottom Layer w0.1: TP152.1@40.8,28.4 v1(41.6,27.6)
N17208347: P100.7 TP153.1 | length 2.8
  Top Layer w0.1: v1(48,28.7) 48.25,28.95 P100.7@48.25,30.175
  Bottom Layer w0.1: TP153.1@47.8,27.6 47.8,28.5 v1(48,28.7)
N17209732: R104.1 SW100.1 SW100.2 | length 5.2
  Top Layer w0.1: R104.1@50.85,14.05 51.9,14.05 SW100.1@51.925,14.075 SW100.2@56.075,14.075
N17211545: C110.1 R150.1 U102.5 | length 7.3
  Top Layer w0.3: R150.1@106.85,50.2 107.51,50.2 v1(107.535,50.175) ; U102.5@111.45,51.5 111.45,52.175 C110.1@111.525,52.25 ; C110.1@111.525,52.375 v1(112,52.375)
  Signal Layer 3 w0.3: v1(107.535,50.175) 109.8,50.175 v1(112,52.375)
N17247543: R7.2 SW1.3 SW1.4 | length 5.3
  Top Layer w0.1: SW1.3@105.075,12.25 SW1.4@109.225,12.25 110.375,12.25 R7.2@110.4,12.225
N17262911: LED100.1 R135.1 | length 1.1
  Top Layer w0.1: LED100.1@69.04,12.51 LED100.1@69,12.55 70.07,12.55 R135.1@70.08,12.56
SI_HEADER_ENABLE: R807.2 U800.5 U800.6 U800.12 U800.13 U802.5 U802.13 U803.C2 U810.5 U810.6 U810.12 U810.13 | length 44.8
  Top Layer w0.1: U803.C2@61.4,35.325 61.8,34.925 v1(61.8,32.35) ; U810.6@69.9,31.3 69.9,31.75 v1(70.15,32) 70.4,31.75 U810.5@70.4,31.3 ; U800.6@69.9,44.8 69.9,45.25 70.075,45.425 v1(70.175,45.425) 70.4,45.2 U800.5@70.4,44.8 ; U802.5@70.4,40.3 70.4,40.775 v1(70.675,41.05) 71.15,41.05 71.625,41.525 71.625,41.975 ; U810.12@71.4,28.9 71.4,28.475 v1(71.625,28.25) 71.9,28.525 U810.13@71.9,28.9 ; U800.12@71.4,42.4 71.4,42.2 71.625,41.975 ; U802.13@71.9,37.9 R807.2@71.9,37.15 71.9,36.825 v1(72.1,36.625) ; U800.13@71.9,42.4 71.9,42.25 71.625,41.975
  Signal Layer 3 w0.1: v1@61.85,32.425 66.175,32.425 66.85,31.75 69.9,31.75 v1(70.15,32)
  Bottom Layer w0.1: v1(70.175,45.425) 72.575,43.025 72.575,41.025 72.1,40.55 72.1,40.175 ; v1(70.675,41.05) 70.675,40.65 71.15,40.175 72.1,40.175 ; v1(71.625,28.25) 70.15,29.725 v1(70.15,32) 70.325,32 70.8,31.525 71.3,31.525 71.893,32.118 71.893,32.882 71.525,33.25 71.525,35.525 72.1,36.1 v1(72.1,36.625) 72.1,40.175
SI_VCOM_CTS: D805.4 P801.8 U810.10 | length 62.6
  Top Layer w0.1: U810.10@70.4,28.9 70.4,28.05 v1(70.475,27.975) ; P801.8@97.905,54.158 97.905,53.37 98.7,52.575 98.95,52.575 99.15,52.375 D805.4@99.15,52.215 99.15,52 98.95,51.8 v1(98.55,51.8)
  Signal Layer 3 w0.1: v1(70.475,27.975) 70.9,27.55 73.975,27.55 75.525,29.1 88.55,29.1 90.45,27.2 97.85,27.2 v1(98.1,26.95)
  Signal Layer 4 w0.1: v1(98.1,26.95) 98.1,34.5 102.6,39 102.6,41.803 98.1,46.303 98.1,51.35 v1(98.55,51.8)
SI_VCOM_RTS: D805.6 P801.6 U810.9 | length 62.5
  Top Layer w0.1: v1(69.85,28.2) 69.9,28.25 U810.9@69.9,28.9 ; P801.6@99.175,54.158 99.175,53.475 99.9,52.75 D805.6@99.9,51.385 99.9,50.675 v1(100.2,50.375)
  Signal Layer 3 w0.1: v1(69.85,28.2) 70.25,28.6 70.6,28.6 71.4,27.8 73.85,27.8 75.5,29.45 88.725,29.45 90.575,27.6 98.5,27.6 v1(98.9,27.2)
  Signal Layer 4 w0.1: v1(98.9,27.2) 98.9,34.169 103.4,38.669 103.4,42.134 100.2,45.334 v1(100.2,50.375)
SI_VCOM_RXD: D805.1 P801.2 U810.2 | length 60.8
  Top Layer w0.1: U810.2@71.9,31.3 71.9,31.375 73.625,31.375 v1(73.9,31.1) ; v1(101.075,51.7) 101,51.7 100.65,52.05 D805.1@100.65,52.215 100.65,52.375 101.715,53.44 P801.2@101.715,54.158
  Signal Layer 3 w0.1: v1(73.9,31.1) 75.2,29.8 89.75,29.8 91.5,28.05 v1(98.5,28.05)
  Signal Layer 4 w0.1: v1(98.5,28.05) 98.5,34.334 103,38.834 103,41.969 98.4,46.569 98.4,50.95 99.15,51.7 v1(101.075,51.7)
SI_VCOM_TXD: D805.2 P801.4 U810.3 | length 58.7
  Top Layer w0.1: U810.3@71.4,31.3 71.4,31.5 71.8,31.9 v1(73.95,31.9) ; P801.4@100.445,54.158 100.15,53.863 D805.2@100.15,52.215 100.15,51.05 100.825,50.375 v1(100.925,50.375)
  Signal Layer 3 w0.1: v1@73.9,31.9 75.65,30.15 90,30.15 91.475,28.675 v1(99.3,28.675)
  Signal Layer 4 w0.1: v1(99.3,28.675) 99.3,34.003 103.8,38.503 103.8,42.3 100.875,45.225 v1@100.875,50.375
TCK_SWCLK: RP800.3 RP801.3 U800.8 U802.11 | length 29.5
  Top Layer w0.1: RP800.3@55,40.65 v1(55.575,40.65) ; RP801.3@67.15,43.8 67.289,43.8 67.539,44.05 68.475,44.05 69.175,43.35 U800.8@69.45,43.35 69.45,43.05 v1@69.203,42.803 ; v1(69.875,37) 70.224,37 70.9,37.676 U802.11@70.9,37.9
  Signal Layer 3 w0.1: v1@55.575,40.75 59.625,36.7 61.65,36.7 62.65,37.7 65.225,37.7 65.7,37.225 67,37.225 67.475,37.7 69.175,37.7 v1(69.875,37)
  Signal Layer 4 w0.1: 69.203,42.35 69.203,41.672 ; v1(69.203,42.802) 69.203,41.672 ; v1(69.875,37) 70.125,37.25 70.125,40.25 69.575,40.8 69.575,41.3 69.203,41.672
TDI: RP800.1 RP801.1 U802.1 U806.8 | length 42.4
  Top Layer w0.1: RP800.1@55,39.65 v1(55.575,39.65) ; RP801.1@67.15,42.8 67.227,42.8 67.652,42.375 v1(68.65,42.375) ; v1@69.45,33.975 U806.8@69.45,34.35 ; U802.1@72.35,39.35 v1(73.35,39.35)
  Signal Layer 3 w0.1: v1@55.575,39.75 59.825,35.5 60.725,35.5 61.725,34.5 68.85,34.5 69.4,33.95 v1(69.4,33.875) 72.575,33.875 73.775,32.675 v1(74.525,32.675) ; v1(68.65,42.375) 69.275,41.75 69.275,41.55 69.575,41.25 69.575,40.75 69.75,40.575 71.2,40.575 71.65,41.025 71.65,41.85 71.9,42.1 72.825,42.1 v1(73.35,41.575)
  Signal Layer 4 w0.1: v1(73.35,41.575) v1(73.35,39.35) 73.9,39.35 74.525,38.725 74.525,35.65 v1(74.525,32.675)
TDO_SWO: R801.1 RP801.2 U800.11 U806.4 | length 13.6
  Top Layer w0.1: RP801.2@67.15,43.3 R801.1@67.85,43.3 68.175,43.625 68.225,43.625 v1(68.25,43.65) ; v1(70.65,36.575) 70.65,36.174 70.9,35.924 U806.4@70.9,35.8 ; U800.11@70.9,42.4 70.9,42.175 71.15,41.925 v1(71.15,41.725)
  Signal Layer 3 w0.1: v1(68.25,43.65) 69.225,43.65 v1(71.15,41.725)
  Signal Layer 4 w0.1: v1(70.65,36.575) 70.65,36.569 71.169,36.05 71.45,36.05 71.7,36.3 71.7,41.175 v1(71.15,41.725)
TMS_SWDIO: RP800.4 RP801.4 U800.4 U802.8 | length 29.2
  Top Layer w0.1: RP800.4@55,41.15 55.075,41.15 v1(55.575,41.65) ; RP801.4@67.15,44.3 67.225,44.3 67.75,44.825 v1(67.75,45.575) 68.025,45.85 70.4,45.85 70.9,45.35 U800.4@70.9,44.8 ; v1(68.65,39.45) 68.575,39.45 69.175,38.85 U802.8@69.45,38.85
  Signal Layer 3 w0.1: v1(55.575,41.65) 56.95,41.65 59,39.6 60.775,39.6 61.4,38.975 63.606,38.975 64.706,40.075 67.975,40.075 68.6,39.45 v1(68.65,39.45)
  Signal Layer 4 w0.1: v1(67.75,45.575) 67.75,42.425 67.525,42.2 67.525,41.825 67.85,41.5 67.85,40.225 68.625,39.45 v1(68.65,39.45)
UIF_BUTTON1: TPJ653.1 U950.11 | length 35.4
  Top Layer w0.1: U950.11@53.625,44.015 53.675,43.965 53.675,43.695 53.845,43.525 54.094,43.525 54.392,43.227 54.392,42.968 v1(54.79,42.57)
  Signal Layer 4 w0.1: v1(54.79,42.57) 54.79,42.5 54.6,42.31 54.6,37.633 57.311,34.923 57.311,16.879 57.69,16.5 v1(57.69,16.48)
  Bottom Layer w0.1: TPJ653.1@51.953,16.102 57.312,16.102 v1(57.69,16.48)
USB_DM: D600.6 P601.A7 P601.B7 R902.1 TPJ612.1 | length 45.6
  Top Layer w0.12: P601.B7@5.95,52.875 6.275,52.875 6.6,53.2 v1(6.725,53.2) ; v1@6.75,52.35 7,52.35 7.225,52.125 P601.A7@7.55,52.125 7.925,52.125 8.175,51.875 D600.6@8.975,51.875 9.778,51.875 10.075,52.172 10.075,52.8 v1(10.025,52.85) ; v1(40.6,41.7) 41.15,41.7 R902.1@41.2,41.75
  Bottom Layer w0.12: v1@6.725,53.15 6.75,53.125 v1@6.75,52.35 ; TPJ612.1@10.15,53.85 10.15,52.975 v1(10.025,52.85) 10.9,51.975 10.9,47.7 16,42.6 37.025,42.6 38.125,41.5 40.325,41.5 40.525,41.7 v1(40.6,41.7)
  other v1: 6.75,52.325
USB_DP: D600.4 P601.A6 P601.B6 R904.1 TPJ611.1 | length 48.6
  Top Layer w0.12: P601.B6@5.95,52.375 6.225,52.375 6.6,52.75 7.075,52.75 7.2,52.625 P601.A6@7.55,52.625 8.05,52.625 8.225,52.8 8.775,52.8 8.85,52.875 D600.4@8.975,52.875 9.138,52.875 9.65,52.363 v1(9.65,52.35) ; v1(40.575,41.05) 40.575,41.173 40.577,41.175 40.9,41.175 R904.1@41.2,40.875
  Bottom Layer w0.12: v1(9.65,52.35) 10.175,52.35 10.55,51.975 10.55,51.762 10.15,51.362 TPJ611.1@10.15,51.3 10.291,51.3 10.66,50.931 10.66,50.47 10.59,50.4 9.347,50.4 9.25,50.303 9.25,50.05 9.4,49.9 10.516,49.9 10.66,49.756 10.66,49.51 10.525,49.375 9.372,49.375 9.297,49.3 9.297,49.02 9.442,48.875 10.53,48.875 10.66,48.745 10.66,47.601 15.901,42.36 36.926,42.36 38.026,41.26 40.315,41.26 40.525,41.05 v1(40.575,41.05)
USBC_CC1: D600.1 P601.A5 R621.2 | length 6.7
  Top Layer w0.3: P601.A5@7.55,53.125 8.175,53.125 v1(8.35,53.3) ; D600.1@10.675,51.875 11.55,51.875 R621.2@11.6,51.825 v1(11.6,51.35)
  Signal Layer 4 w0.3: v1(8.35,53.3) 8.975,52.675 8.975,52.075 9.7,51.35 v1(11.6,51.35)
USBC_CC2: D600.3 P601.B5 R620.2 | length 7.7
  Top Layer w0.25: P601.B5@5.95,51.875 6.525,51.875 6.7,51.7 v1@6.725,51.7
  Top Layer w0.3: v1(9.15,53.525) 10.25,53.525 10.625,53.15 10.625,52.925 D600.3@10.675,52.875 10.693,52.893 11.5,52.893 11.5,52.875 R620.2@11.6,52.975
  Signal Layer 3 w0.3: v1@6.725,51.7 8.575,51.7 9.15,52.275 v1(9.15,53.525)
  other v1: 6.725,51.675
USBC_VBUS: D600.5 L600.1 P601.A4 P601.A9 P601.B4 P601.B9 TPJ613.1 | length 16.1
  Top Layer w0.25: P601.B4@5.95,51.375 6.323,51.375 6.725,50.973 v1(6.725,51.025) 6.725,51.05 6.925,51.05 7,51.125 P601.A9@7.55,51.125 ; P601.B9@5.95,53.875 6.7,53.875 v1(6.725,53.85) 6.825,53.85 7.05,53.625 P601.A4@7.55,53.625
  Top Layer w0.35: v1(8.4,52.375) D600.5@8.975,52.375
  Top Layer w0.5: v1(8.375,53.925) 8.66,53.925 L600.1@9.135,54.4
  Signal Layer 4 w0.5: v1(6.725,51.025) 7.125,51.025 7.45,51.35 7.45,52.2 7.625,52.375 ; v1(6.725,53.85) 7.025,53.85 7.5,53.375 ; v1(8.375,53.925) 8,53.925 7.5,53.425 7.5,53.375 ; v1(8.4,52.375) 7.625,52.375 ; 7.5,53.375 7.5,52.5 7.625,52.375
  Bottom Layer w0.3: v1(8.375,53.925) 9.25,54.8 11.75,54.8 TPJ613.1@12.7,53.85
V_SW: C104.1 C800.1 C828.1 C950.1 Q600.4 Q601.6 TPJ608.1 U100.10 U805.14 U812.14 U950.14 | length 91.2
  Top Layer w0.2: U100.10@41.375,29.975 41.675,29.975 41.9,30.2 C104.1@42.175,30.2 v1(42.175,29.7) ; U950.14@54.11,45.1 54.725,45.1 C950.1@54.9,45.275 v1@55.4,45.275 ; v1(63.521,36.25) 63.55,36.25 63.525,36.275 63.225,36.275 C800.1@63.1,36.4 63.57,36.87 U805.14@63.89,36.87 ; v1(65.125,29.85) 65.125,29.7 C828.1@65.4,29.425 65.825,29.85 U812.14@66.215,29.85
  Top Layer w0.3: 21.45,25.475 22.282,25.475 22.341,25.416 ; 21.45,25.475 Q600.4@21.45,25.625 ; 21.45,25.475 21.7,25.225 v1(21.85,25.225) 22.15,25.225 22.341,25.416 ; Q600.4@21.45,25.625 Q601.6@22.4,25.625 ; Q600.4@21.45,25.625 Q600.4@21.45,25.875 Q601.6@22.4,25.875 Q601.6@22.4,25.625 ; 22.341,25.416 22.4,25.475 Q601.6@22.4,25.625
  Signal Layer 3 w0.4: v1(55.4,45.287) 56.213,45.287 60.5,41 v1(60.675,41)
  Signal Layer 3 w0.5: v1(21.85,25.225) 22.45,24.625 23.525,24.625 23.8,24.9 24.55,24.9 26.375,23.075 v1(41.225,23.075) 58,23.075 v1(59.25,21.825)
  Signal Layer 4 w0.4: v1(41.225,23.075) 41.225,26.3 42.275,27.35 42.275,29.6 v1(42.175,29.7) ; v1(59.25,21.825) 59.25,24.575 60.087,25.412 60.087,27.688 61.3,28.9 62.3,28.9 63.25,29.85 ; v1(60.675,41) 60.675,39.65 62.325,38 62.325,36.85 62.925,36.25 v1(63.521,36.25) 63.5,36.229 63.5,32.475 63.25,32.225 63.25,29.85 ; v1(65.125,29.85) 63.25,29.85
  Bottom Layer w0.4: v1(34.525,23.05) 34.528,23.047 TPJ608.1@34.528,20.527
VCOM_CTS: U812.9
VCOM_ENABLE: Q807.2 R310.2 R311.1 R839.2 | length 28.3
  Top Layer w0.1: v1(61.85,28.23) 61.855,28.225 R839.2@63.8,28.225 63.8,29.075 64.225,29.5 Q807.2@64.425,29.5 ; R311.1@64,5.75 63.3,5.75 63.11,5.94 63.11,7.1 63.05,7.16 63.05,7.3 v1(63.3,7.55) R310.2@64,7.55
  Signal Layer 4 w0.1: v1(61.85,28.23) 61.85,27.82 61.85,24.55 62.4,24 62.4,8.45 v1(63.3,7.55)
VCOM_RTS: U812.10
VCS: C710.1 C714.1 C728.1 R717.2 U703.7 | length 3.7
  Top Layer w0.25: C710.1@26.675,39.65 U703.7@27.45,39.65
  Top Layer w0.3: C710.1@26.65,39.625 C710.1@26.675,39.65
  Top Layer w0.5: R717.2@26.5,37.5 26.5,38.45 C714.1@26.4,38.55 26.05,38.9 C728.1@26.05,39.625 C710.1@26.65,39.625
VDISP: C143.1 C144.1 P100.4 P100.5 P100.6 R145.2 U100.12 | length 17
  Top Layer w0.2: U100.12@41.375,30.775 42.15,30.775 C144.1@42.175,30.75 v1(42.175,31.225) ; P100.4@46.75,30.175 C143.1@46.75,31.25 47.25,31.25 ; P100.5@47.25,30.175 47.25,31.25 ; P100.6@47.75,30.175 47.75,31.175 v1(47.725,31.2) ; R145.2@52.9,31.3 52.8,31.2 v1(47.725,31.2) ; 47.25,31.25 47.675,31.25 v1(47.725,31.2)
  Signal Layer 3 w0.4: v1(42.175,31.225) 42.375,31.425 43.375,31.425 44.35,30.45 46.975,30.45 v1(47.725,31.2)
VMCU: C1.1 C2.1 C706.1 D808.1 J101.1 P101.2 P801.1 Q600.1 Q601.3 R9.1 R100.2 R108.1 R109.1 R111.2 R150.2 R308.1 R310.1 SW704.5 TP157.1 TP703.1 U1.4 U100.11 | length 83.9
  Top Layer w0.1: R310.1@64,8.45 v1(64,9.15)
  Top Layer w0.2: v1(40.725,30.375) U100.11@41.375,30.375 ; v1(82.2,12.7) 82.212,12.688 R111.2@82.788,12.688 ; C2.1@84.1,34.5 U1.4@85.025,34.5 ; v1(103.4,15.7) 103.5,15.6 R9.1@103.5,15.1
  Top Layer w0.3: v1(19.577,24.551) 19.577,24.548 19.65,24.475 20.35,24.475 Q600.1@20.45,24.575 ; v1(23.4,23.8) Q601.3@23.4,24.575 ; v1(26,5.9) 26,5.925 C706.1@26,6.425 ; R100.2@51,12.3 51.025,12.3 51.35,12.625 v1(51.575,12.625) ; R308.1@65.53,54.25 68.36,54.25 76.2,46.41 76.2,36.5 80.03,32.67 82.4,32.67 v1(83.05,33.32) 83.05,33.376 83.1,33.426 C1.1@83.1,34 83.6,34.5 C2.1@84.1,34.5 v1(84.1,33.85) ; v1(105.2,50.2) R150.2@105.95,50.2 ; R108.1@106.25,49.5 105.95,49.8 R150.2@105.95,50.2 ; R109.1@106.25,50.95 105.95,50.65 R150.2@105.95,50.2
  Top Layer w0.635: SW704.5@20.9,1.75 v1(20.9,3.575) v1(20.9,4.325) ; v1(100.2,17.45) v1(100.875,17.45) v1(101.55,17.45) 102.475,17.45 103.595,18.57 P101.2@104.57,18.57 ; P801.1@101.715,57.841 101.715,57.085 102.6,56.2 v1@102.6,51.35
  Signal Layer 3 w0.6: v1(19.577,24.551) 20.999,24.551 21.75,23.8 v1(23.4,23.8) 24.825,22.375 v1(30.1,22.375) v1(30.9,22.375)
  Signal Layer 4 w0.3: v1(19.577,24.551) v1@19.625,24.503
  Signal Layer 4 w0.5: v1(38.95,22.375) 38.95,27 40.725,28.775 v1(40.725,30.375)
  Bottom Layer w0.3: TP157.1@81.4,34 82.08,33.32 v1(83.05,33.32)
  Bottom Layer w0.635: TP703.1@28.9,4.7 29.512,4.7 J101.1@30.95,3.262
  other v1: 102.6,51.325
VMCU_BUF: C625.1 C861.1 C863.1 C865.1 C867.1 R630.2 R675.2 U806.2 U860.6 U861.6 U862.6 U863.6 | length 110
  Top Layer w0.2: U860.6@51.6,47.65 51.65,47.65 52.175,47.125 C863.1@52.175,47.05 52.175,46.525 v1(52.15,46.5) ; C861.1@61.45,38.55 U862.6@62.1,38.55 ; v1(66.175,34.1) 66.225,34.15 C867.1@66.725,34.15 U863.6@67.35,34.15 ; C865.1@66.65,40.275 67.225,40.275 U861.6@67.25,40.25
  Top Layer w0.3: R630.2@52.15,32.2 v1(52.625,32.2) ; v1(61.45,38) C861.1@61.45,38.55 ; v1(66.075,40.65) 66.425,40.3 66.65,40.3 C865.1@66.65,40.275 ; U806.2@71.9,35.8 71.9,35.95 72.075,36.125 72.65,36.125 73.125,36.6 v1(73.275,36.6)
  Top Layer w0.5: C625.1@33.3,27.475 R675.2@33.3,26.425 v1(34,26.425)
  Signal Layer 3 w0.5: v1(34,26.425) 35.975,24.45 58.05,24.45 v1(58.575,24.975) v1(59.113,25.512) ; v1(58.265,38.85) 60.6,38.85 v1(61.45,38)
  Signal Layer 4 w0.35: 55.275,45.85 55.3,45.825 55.825,45.825
  Signal Layer 4 w0.4: v1(52.15,46.5) 52.15,46.4 52.525,46.025 53.475,46.025 53.85,45.65 54.825,45.65 55.025,45.85 55.275,45.85
  Signal Layer 4 w0.5: 55.825,45.825 56.575,45.075 56.575,41.7 58.265,40.01 v1(58.265,38.85)
  Bottom Layer w0.3: v1(52.625,32.2) 53,31.825 55.225,31.825 ; v1(72.975,28.3) 72.975,29.7 72.1,30.575 72.1,31.075 72.625,31.6 72.625,34.25 73.275,34.9 v1(73.275,36.6)
  Bottom Layer w0.5: 55.225,31.825 56.6,30.45 59.65,30.45 ; v1(58.575,24.975) v1(59.113,25.512) 59.65,26.05 59.65,27.45 ; v1(61.45,38) v1@61.388,38.063 ; v1(66.075,40.65) 63.6,40.65 62.75,39.8 62.75,39.425 v1@61.388,38.063 ; v1(66.175,34.1) 62.35,34.1 60.875,32.625 59.65,32.625 ; v1(72.975,28.3) 72,27.325 69.8,27.325 69.125,26.65 66.05,26.65 65.25,27.45 59.65,27.45 ; 59.65,27.45 59.65,30.45 ; 59.65,30.45 59.65,32.625 ; 59.65,32.625 59.65,36.325 v1@61.388,38.063
VMCU_R: C761.1 C762.1 R701.1 R702.2 R709.2 TP700.1 U701.1 U701.4 | length 20.4
  Top Layer w0.1: R709.2@30.35,36.2 29.825,35.675 29.825,35 30.125,34.7 R701.1@31.175,34.7
  Top Layer w0.25: v1(29.825,32.7) 29.875,32.65 U701.4@30.35,32.65 ; U701.1@31.85,32.65 v1@32.325,32.65
  Top Layer w0.3: v1(30.075,28.325) 30.325,28.575 R702.2@30.325,28.85
  Top Layer w0.5: C762.1@28.2,33.225 29.025,33.225 C761.1@29.1,33.15 ; R701.1@31.175,34.7 31.175,34.425 30.66,33.91 30.485,33.91 v1(29.85,33.275) ; C761.1@29.1,33.15 29.225,33.275 29.538,33.275 ; C761.1@29.1,33.15 29.538,32.713 ; 29.538,32.713 29.538,33.275 ; 29.538,32.713 29.55,32.7 v1(29.825,32.7) 29.85,32.725 v1(29.85,33.275) ; 29.538,33.275 v1(29.85,33.275)
  Signal Layer 3 w0.6: v1(29.85,33.275) 29.825,33.25 v1(29.825,32.7) 29.95,32.575 32.35,32.575 v1(32.375,32.6)
  Signal Layer 4 w0.5: v1(29.85,33.275) 29.85,31.675 29.975,31.55 29.975,28.425 v1(30.075,28.325)
  Bottom Layer w0.5: v1(29.825,32.7) 29.825,34.325 TP700.1@29.9,34.4
VMCU_S: C700.1 C701.1 R701.2 R710.2 R760.2 TP701.1 TP705.1 U700.3 U702.2 U702.4 U702.9 U702.10 | length 34
  Top Layer w0.1: R701.2@28.325,34.7 29.325,34.7 29.625,35 29.625,35.725 R710.2@29.15,36.2
  Top Layer w0.2: U702.10@41.815,36.675 42.5,36.675 v1(42.602,36.777) ; U702.9@41.815,37.075 42.25,37.075 v1@42.475,36.85 ; U702.2@43.585,36.275 43.2,36.275 42.698,36.777 v1(42.602,36.777) ; U702.4@43.585,37.075 43.175,37.075 43,36.9 42.725,36.9 v1(42.602,36.777)
  Top Layer w0.25: U700.3@24.75,34.075 24.75,35.2 v1(25.025,35.475)
  Top Layer w0.3: v1(25.025,35.475) 25.125,35.575 R760.2@25.55,35.575
  Top Layer w0.5: R760.2@25.55,35.575 26.575,35.575 C700.1@27,35.15 ; v1@27.556,35.844 v1(27.556,35.831) 27.556,35.706 C700.1@27,35.15 ; R701.2@28.325,34.7 27.938,34.313 27.2,34.313 27.2,34.95 C700.1@27,35.15
  Signal Layer 3 w0.6: v1(25.025,35.475) 25.381,35.831 v1(27.556,35.831) 28.131,35.831 28.9,36.6 42.425,36.6 v1(42.602,36.777)
  Bottom Layer w0.5: v1(27.556,35.831) 28.431,35.831 TP701.1@28.6,36 ; TP705.1@41.6,36.2 42.177,36.777 v1(42.602,36.777)
VMCU_SENSE: C632.1 R630.1 R631.2 TP708.1 U910.6 | length 4.9
  Top Layer w0.1: v1(49.575,34.1) 49.65,34.025 U910.6@50.625,34.025 50.65,34 51.05,34 C632.1@51.05,32.775 51.075,32.8 R631.2@51.6,32.8 R630.1@52.15,32.8
  Bottom Layer w0.1: TP708.1@48.8,34.8 49.5,34.1 v1(49.575,34.1)
VREF: C3.1 C4.1 R5.1 TP158.1 | length 4.5
  Top Layer w0.3: v1(81.69,35.79) 81.73,35.83 81.73,35.93 81.925,36.125 81.925,36.15 82.175,36.4 R5.1@83.25,36.4 83.25,37.15 C4.1@83.2,37.2
  Bottom Layer w0.3: TP158.1@80.4,36.4 81.45,36.4 81.69,36.16 v1(81.69,35.79)
VTARGET: R629.2 R691.1 U800.1 U806.1 | length 23
  Top Layer w0.2: R629.2@69.3,26.5 69.95,26.5 R691.1@70,26.45 v1(70.675,26.45)
  Top Layer w0.3: U806.1@72.35,34.85 72.45,34.85 72.575,34.975 v1(72.575,35.325) ; U800.1@72.35,43.85 72.53,43.85 v1(72.53,44.64)
  Signal Layer 4 w0.3: v1(70.675,26.45) 72.45,28.225 v1(72.45,29.025) 71.65,29.825 71.65,31.275 72.2,31.825 72.2,34.95 v1(72.575,35.325) 72.593,35.343 72.593,39.668 73.025,40.1 73.025,40.65 72.85,40.825 72.85,44.32 v1(72.53,44.64)
VTARGET_BUF: C655.1 C806.1 L801.1 R636.2 R687.2 R801.2 R809.2 U808.23 U808.24 | length 59.9
  Top Layer w0.2: v1(64.05,47.35) 64.175,47.225 C806.1@64.175,46.85
  Top Layer w0.3: R636.2@47.2,32.8 47.2,33.625 v1(47.35,33.775) ; L801.1@54.7,37.3 L801.1@54.709,37.309 ; R809.2@54.925,38.125 54.925,37.525 L801.1@54.709,37.309 ; v1(55.575,37.312) 55.572,37.309 L801.1@54.709,37.309 ; C806.1@64.15,46.825 U808.24@64.15,45.845 65.005,45.845 65.195,45.655 U808.23@65.195,45.3 ; R801.2@67.85,42.7 68.1,42.7 68.45,43.05 v1(68.525,43.05)
  Top Layer w0.4: v1@61.125,25.5 C655.1@61.8,25.5 R687.2@61.8,26.55
  Signal Layer 3 w0.4: v1(47.35,33.775) 47.35,34.15 47.85,34.65 51.775,34.65 52.7,33.725 ; v1(55.575,37.312) 55.575,36.6 52.7,33.725 ; v1(61.075,25.5) 61.075,27.825 58.9,30 54.15,30 53.425,30.725 53.425,33 52.7,33.725
  Bottom Layer w0.3: v1(68.525,43.05) 68.85,43.375 68.85,43.954 68.625,44.179
  Bottom Layer w0.4: v1(55.575,37.312) 59.637,37.312 60.775,38.45 60.775,40.15 61.9,41.275 61.9,45.2 v1(64.05,47.35) 64.65,47.95 66.1,47.95 66.5,48.35 67.75,48.35 68.625,47.475 68.625,44.179
VTARGET_SENSE: C638.1 R636.1 R637.2 U910.5 | length 3.2
  Top Layer w0.1: C638.1@46.1,32.775 46.125,32.8 R637.2@46.65,32.8 ; U910.5@46.225,34.025 U910.5@46.65,34.025 ; U910.5@46.775,34.025 U910.5@46.65,34.025 ; R636.1@47.2,32.2 47.2,32.25 R637.2@46.65,32.8 ; R637.2@46.65,32.8 U910.5@46.65,34.025
VTREF: Q800.4 R816.2 TPJ817.1 U800.2 | length 51.3
  Top Layer w0.3: Q800.4@67.325,36.65 67.325,35.725 v1(67.45,35.6) ; U800.2@71.9,44.8 71.9,45.65 R816.2@71.95,45.7 72.025,45.775 v1(72.025,46.55)
  Signal Layer 3 w0.3: v1(67.2,46) 67.325,46.125 68.45,46.125 69.725,44.85 70.325,44.85 v1(72.025,46.55) 100.85,46.55 v1(101.875,47.575)
  Signal Layer 4 w0.3: v1(67.2,46) 66.65,45.45 66.65,39.425 67.175,38.9 67.175,37.825 67.45,37.55 v1(67.45,35.6)
  Bottom Layer w0.5: v1(101.875,47.575) TPJ817.1@102.65,48.35
pads on no net: D800.5 D801.1 D903.2 D903.4 D903.5 J101.3 J101.4 J101.5 J101.6 J102.3 J102.7 J102.8 J102.9 J102.10 M2.1 M3.1 P100.11 P100.12 P101.M1 P101.M2 P601.25@1.8,56.82 P601.26@1.8,48.18 P601.27@6.2,56.525 P601.27@6.85,56.82 P601.28@6.2,48.475 P601.28@6.85,48.18 P601.A2 P601.A3 P601.A8 P601.A10 P601.A11 P601.B2 P601.B3 P601.B8 P601.B10 P601.B11 P601.M1 P601.M2 P800.7 P800.11 P800.13 P801.10 P801.12 P801.14 P801.16 P801.18 P801.20 P801.M1 P801.M2 Q100.3 RP800.2 RP800.7 SW105.7 SW105.8 SW105.M1 SW105.M2 U102.3 U102.4 U102.7 U600.8 U701.8 U800.17 U802.17 U806.17 U808.8 U808.9 U808.10 U810.17 U900.B11 U900.E11 U900.E12 U900.F12 U900.G2 U900.H2 U900.J2 U900.L3 U900.L8 U900.L10 U900.L12 U900.L13 U900.M4 U900.M12 U900.N6 U900.N7 U900.N12 U901.9 U902.C1
copper on no net: | length 2.1
  Bottom Layer w0.1: 26.767,30.646 26.767,29.633 26.8,29.6 ; 28.725,29.9 29.8,29.9

## Polygon pours and split planes (outlines as drawn)
GND on VCC Layer 5 "GND_L05_P003" (solid, remove dead copper, pour order 3): 44.25,36.5 44.25,40.5 42.65,40.5 42.65,43.3 28.35,43.3 25.65,46 18.275,46 12.6,51.675 12.6,55.6 12.6,60 0,60 0,46.25 0,36.5
VMCU on VCC Layer 5 "VMCU_L05_P005" (solid, remove dead copper, pour order 5): 20.375,0 20.375,6.425 29.725,6.425 29.725,23.5 69.3,23.5 69.3,40 102.725,40 102.725,43.325 101.075,43.325 101.075,60 115,60 115,0
3V3 on VCC Layer 5 "3V3_L05_P004" (solid, remove dead copper, pour order 4): 44.511,36.2 44.511,40.7 42.9,40.7 42.9,43.6 28.35,43.6 25.65,46.3 18.325,46.3 12.825,51.8 12.825,60 33,60 100.575,60 100.575,43 102.4,43 102.4,40.375 68.925,40.375 68.925,24 29.3,24 29.3,6.775 20.075,6.775 20.075,0 0,0 0,36.2
GND on Bottom Layer "GND_L06_P008" (solid, remove dead copper, pour order 8): 0,0 0,60 125,60 125,0
GND on Signal Layer 3 "GND_L03_P011" (solid, remove dead copper, pour order 11): 0,0 0,60 125,60 125,0
GND on Signal Layer 4 "GND_L04_P012" (solid, remove dead copper, pour order 12): 0,0 0,60 125,60 125,0
GND on GND Layer 2 "GND_L02_P015" (solid, remove dead copper, pour order 15): 0,0 0,60 125,60 125,0
GND on Top Layer "GND_L01_P013" (solid, remove dead copper, pour order 13): 0,0 0,60 115,60 115,0