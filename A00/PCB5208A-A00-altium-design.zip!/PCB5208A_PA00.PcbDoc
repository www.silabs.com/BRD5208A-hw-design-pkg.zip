# Altium PCB PCB5208A_PA00.PcbDoc (part 3 of 5)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 115 x 60 mm, 6 copper layers (Top Layer, GND Layer 2, Signal Layer 3, Signal Layer 4, VCC Layer 5, Bottom Layer), stack 1.555 mm thick; 368 components, 246 nets, 1220 pads, 779 vias.

## Via types
v1: diameter 0.508, hole 0.25, Top Layer to Bottom Layer, tented both sides, 779 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DEBUG_TMS_SWDIO_IN: U808.3 U900.M3 | length 15.4
  Top Layer w0.1: U900.M3@48.6,47 48.85,47.25 49.704,47.25 50.029,47.575 v1(50.175,47.575) ; v1(61.025,45.8) 60.875,45.65 60.875,45.125 61.2,44.8 U808.3@61.605,44.8
  Signal Layer 3 w0.1: v1(50.175,47.575) 50.4,47.8 51.925,47.8 52.175,48.05 53.15,48.05 53.6,47.6 55.5,47.6 56.925,46.175 60.65,46.175 v1(61.025,45.8)
DEBUG_TMS_SWDIO_OUT: U804.D2 U900.C2 | length 5
  Top Layer w0.1: U900.C2@49.1,42.5 49.35,42.25 49.35,41.9 49.35,41.896 49.496,41.75 49.925,41.75 50.1,41.575 50.1,40.925 50.25,40.775 50.25,40.45 50.675,40.025 50.675,39.225 51,38.9 U804.D2@51.325,38.9
DEBUG_TRACECLK: D801.2 P800.12 | length 3.2
  Top Layer w0.1: D801.2@75.95,52.215 75.95,52.35 76.25,52.65 77.3,52.65 77.865,53.215 P800.12@77.865,54.05
DEBUG_TRACED0: D801.3 P800.14 | length 2.5
  Top Layer w0.1: D801.3@75.45,52.215 75.45,52.375 75.95,52.875 76.225,52.875 76.595,53.245 P800.14@76.595,54.05
DEBUG_TRACED1: D801.4 P800.16 | length 2
  Top Layer w0.1: D801.4@74.95,52.215 74.95,52.75 75.325,53.125 P800.16@75.325,54.05
DEBUG_TRACED2: D801.5 P800.18 | length 3.4
  Top Layer w0.1: P800.18@74.055,54.05 74.055,52.17 74.475,51.75 75,51.75 75.2,51.55 D801.5@75.2,51.385
DEBUG_TRACED3: D801.6 P800.20 | length 5.3
  Top Layer w0.1: P800.20@72.785,54.05 72.785,52.615 74.475,50.925 75.4,50.925 75.7,51.225 D801.6@75.7,51.385
DH_#RESET: D800.4 P800.10 R816.1 TPJ811.1 U802.3 | length 32.5
  Top Layer w0.1: U802.3@71.4,40.3 71.4,40.15 71.8,39.75 73.075,39.75 v1(73.925,40.6) ; R816.1@72.85,45.7 v1@74.175,45.7 ; P800.10@79.135,54.05 79.135,53.24 79.725,52.65 80.425,52.65 80.65,52.425 D800.4@80.65,52.215 80.585,52.15 79.85,52.15 v1(79.85,52.193)
  Signal Layer 3 w0.1: v1(71.85,52.875) 79.168,52.875 v1(79.85,52.193)
  Signal Layer 4 w0.1: v1(71.85,52.875) 71.85,48.125 v1(74.275,45.7) 74.725,45.25 74.725,41.4 v1(73.925,40.6)
  Bottom Layer w0.1: TPJ811.1@77.9,52.7 79.343,52.7 v1(79.85,52.193)
DH_TCK_SWCLK: D800.1 P800.4 TPJ818.1 U800.9 | length 30
  Top Layer w0.1: v1(69.725,41.75) 69.725,41.95 69.9,42.125 U800.9@69.9,42.4 ; v1(82.725,52.15) 82.215,52.15 D800.1@82.15,52.215 82.15,52.425 82.945,53.22 P800.4@82.945,54.05
  Signal Layer 3 w0.1: v1(68.95,50.275) 79.5,50.275 81.375,52.15 v1(82.725,52.15)
  Signal Layer 4 w0.1: v1(68.95,50.275) 68.95,45.425 69.725,44.65 v1(69.725,41.75)
  Bottom Layer w0.1: v1(69.725,41.75) 70.175,42.2 71.35,42.2 71.55,42 TPJ818.1@71.55,40.95
DH_TDI: D800.3 P800.8 TPJ820.1 U802.2 | length 25.3
  Top Layer w0.1: U802.2@71.9,40.3 72.475,40.3 v1(72.5,40.325) ; P800.8@80.405,54.05 80.405,53.17 81.15,52.425 D800.3@81.15,52.215 81.15,51 80.975,50.825 v1(80.975,50.375)
  Signal Layer 3 w0.1: v1(71.272,49.3) 79.9,49.3 v1(80.975,50.375)
  Signal Layer 4 w0.1: v1(71.272,49.3) 71.272,46.328 72.02,45.58 72.02,43.91 72.5,43.43 v1(72.5,40.325)
  Bottom Layer w0.1: TPJ820.1@80.2,50.95 80.4,50.95 v1(80.975,50.375)
DH_TDO_SWO: D800.2 P800.6 TPJ812.1 U800.10 | length 28.9
  Top Layer w0.1: v1@70.4,41.825 U800.10@70.4,42.4 ; P800.6@81.675,54.05 81.65,54.025 D800.2@81.65,52.215 81.65,51.05 82,50.7 v1(82.15,50.7)
  Signal Layer 3 w0.1: v1(69.475,49.75) 79.675,49.75 80.9,50.975 81.875,50.975 v1(82.15,50.7)
  Signal Layer 4 w0.1: v1(69.475,49.75) 69.475,45.375 70.4,44.45 v1(70.4,41.725)
  Bottom Layer w0.1: TPJ812.1@81.65,53.45 81.65,51.2 v1(82.15,50.7)
DH_TMS_SWDIO: D800.7 P800.2 TPJ814.1 U800.3 | length 26.5
  Top Layer w0.1: v1(70.5,46.3) 71.4,45.4 U800.3@71.4,44.8 ; v1(82.825,50.725) 82.35,51.2 81.925,51.2 81.9,51.225 D800.7@81.9,51.385 81.9,51.525 82.075,51.7 83.025,51.7 83.675,52.35 83.675,52.675 84.215,53.215 P800.2@84.215,54.05 84.215,55.665 v1(84.225,55.675)
  Signal Layer 3 w0.1: v1(70.5,49.3) 70.925,48.875 80.975,48.875 v1(82.825,50.725)
  Signal Layer 4 w0.1: v1@70.5,46.475 v1(70.5,49.3) v1(70.5,49.3)
  Bottom Layer w0.1: v1(84.225,55.675) 84.225,54.425 TPJ814.1@84.35,54.3
DH_VTREF: D809.1 P800.1 Q800.3 | length 38.3
  Top Layer w0.3: Q800.3@67.325,37.95 67.325,38.3 v1(67.7,38.675)
  Top Layer w0.635: P800.1@84.215,57.95 84.215,57.193 85.1,56.309 v1(85.1,50.825)
  Signal Layer 3 w0.5: v1(67.275,47.65) 67.95,48.325 82.6,48.325 v1(85.1,50.825)
  Bottom Layer w0.35: 66.65,41.85 66.65,40.877 66.725,40.802
  Bottom Layer w0.5: 66.65,41.85 65.4,43.1 65.4,45.95 67.1,47.65 v1(67.275,47.65) ; 66.725,40.802 66.725,39.65 v1(67.7,38.675)
DISP_CS: R300.2 U100.7 | length 42.4
  Top Layer w0.1: v1(40.575,27.225) 40.775,27.425 U100.7@40.775,28.975 ; R300.2@61.4,6.65 v1(61.4,7.35)
  Signal Layer 3 w0.1: v1(40.575,27.225) 41,26.8 57.825,26.8 v1(58.4,27.375)
  Signal Layer 4 w0.1: v1(58.4,27.375) 58,26.975 58,23.8 58.5,23.3 58.5,10.25 v1(61.4,7.35)
DISP_ENABLE: Q100.2 R141.2 R304.2 R308.2 U100.6 U100.14 | length 57.2
  Top Layer w0.1: v1(39.825,26.975) 39.825,27.075 40.4,27.65 R141.2@40.4,28.25 40.4,28.95 U100.6@40.375,28.975 40.375,30.125 40.325,30.175 40.325,30.675 40.775,31.125 U100.14@40.775,31.375 ; Q100.2@58.275,50 v1(59.3,50) ; v1(64,52.7) R304.2@64,53.35 R308.2@65.53,53.35
  Signal Layer 3 w0.1: v1(39.825,26.975) 40.25,26.55 58.65,26.55 v1(58.975,26.875)
  Signal Layer 4 w0.1: v1(58.975,26.875) 58.975,35.675 60.05,36.75 60.05,45.25 59.3,46 v1(59.3,50) 62,52.7 v1(64,52.7)
DISP_SCLK: J101.8 U1.12 U100.15 | length 96.3
  Top Layer w0.1: U100.15@40.375,31.375 v1(40.375,32) ; U1.12@87.9,35.5 89.06,35.5 v1(89.5,35.94)
  Signal Layer 3 w0.1: J101.8@48.73,3.262 50,4.532 55.368,9.9 56.325,9.9 60,13.575 66.375,13.575 76.85,24.05 v1(89.3,24.05)
  Signal Layer 4 w0.1: v1(40.375,32) 41.15,31.225 41.15,27.1 40.65,26.6 40.65,21.6 47.475,14.775 47.475,4.517 J101.8@48.73,3.262 ; v1(89.3,24.05) 89.675,24.425 89.675,34.895 89.5,35.07 v1(89.5,35.94)
DISP_SI: J102.13 U1.9 U100.3 | length 122.6
  Top Layer w0.1: v1(38.025,29.7) 38.3,29.975 U100.3@39.775,29.975 ; U1.9@87.6,34 87.73,33.87 88.95,33.87 89.2,34.12 89.2,34.725 v1(90.15,35.675)
  Signal Layer 3 w0.1: v1(38.025,29.7) 39.85,29.7 41.25,28.3 42.25,28.3 42.325,28.225 48.125,28.225 48.6,28.7 58.025,28.7 59.6,27.125 59.6,24.525 60.125,24 65.8,24 66.525,23.275 73.875,23.275 76.625,26.025 83.5,26.025 84.568,27.093 89.782,27.093 v1(90.725,26.15) ; J102.13@61.43,56.602 62.428,57.6 69.475,57.6 72.25,54.825 87.7,54.825 v1(88.225,54.3)
  Signal Layer 4 w0.1: v1(88.225,54.3) 90.15,52.375 v1(90.15,35.675) 90.15,29.5 90.725,28.925 v1(90.725,26.15)
EXP_HEADER3: C102.1 J101.12 P101.3 R100.1 SW100.3 SW100.4 TPJ652.1 U1.16 U950.8 | length 136.5
  Top Layer w0.1: C102.1@50.45,11.725 50.975,11.725 R100.1@51,11.7 51.225,11.925 SW100.3@51.925,11.925 SW100.4@56.075,11.925 v1(57.075,11.925) ; v1(51.9,44.088) 52.353,44.088 U950.8@52.425,44.015 ; v1(85.85,37.475) 85.85,37.023 86.1,36.773 U1.16@86.1,36.3 ; v1(106.86,21.14) 106.89,21.11 P101.3@108.76,21.11
  Signal Layer 3 w0.1: J101.12@58.89,3.262 60.2,4.572 60.2,5.398 62.927,8.125 67.75,8.125 79.425,19.8 v1(83.35,19.8) 96.25,19.8 97.59,21.14 v1(106.86,21.14)
  Signal Layer 4 w0.1: v1(51.9,44.088) 52.787,44.088 54.4,42.475 54.4,37.5 57.075,34.825 v1(57.075,11.925) ; v1(83.35,19.8) 82.23,20.92 82.23,33.63 84.45,35.85 84.98,35.85 85.85,36.72 v1(85.85,37.475)
  Bottom Layer w0.1: v1(57.075,11.925) v1@57.1,11.9 ; J101.12@58.89,3.262 57.5,4.652 57.5,11.5 v1@57.1,11.9 ; TPJ652.1@61.303,16.102 v1@57.1,11.9
EXP_HEADER4: P101.4
EXP_HEADER5: P101.5 R307.2 | length 8.2
  Top Layer w0.1: R307.2@101.22,22.79 101.464,22.546 101.504,22.546 101.64,22.41 106.55,22.41 107.79,23.65 P101.5@108.76,23.65
EXP_HEADER6: P101.6
EXP_HEADER7: C106.1 J101.7 P101.7 R111.1 SW105.5 U1.10 | length 101.4
  Top Layer w0.1: v1(82.8,13.525) 83.212,13.113 84.522,11.802 SW105.5@84.522,11.528 ; U1.10@87.9,34.5 88.52,34.5 v1(88.61,34.41) ; v1(106.89,26.19) P101.7@108.76,26.19
  Signal Layer 3 w0.1: J101.7@46.19,3.262 46.19,6.471 46.219,6.5 ; 46.22,6.5 48.3,8.58 52.41,8.58 58.3,14.47 66.22,14.47 76.8,25.05 83.3,25.05 84.63,26.38 v1(86.85,26.38) 89.46,26.38 90.31,25.53 99.06,25.53 99.72,26.19 v1(106.89,26.19)
  Signal Layer 4 w0.1: v1(82.8,13.525) 86.85,17.575 v1(86.85,26.38) 86.85,32.65 v1(88.61,34.41)
EXP_HEADER8: P101.8
EXP_HEADER9: P101.9 | length 1
  Top Layer w0.1: P101.9@107.77,28.73 P101.9@108.76,28.73
EXP_HEADER10: P101.10
EXP_HEADER11: P101.11
EXP_HEADER12: J101.10 P101.12 U1.14 U812.2 | length 95.2
  Top Layer w0.1: v1(66.65,28.5) 66.625,28.5 66.7,28.575 U812.2@66.7,29.165 ; v1(86.85,37.475) 86.85,37.01 87.1,36.76 U1.14@87.1,36.3 ; v1(102.72,32.12) 103.57,31.27 P101.12@104.57,31.27
  Signal Layer 3 w0.1: J101.10@53.81,3.262 61.573,11.025 67.425,11.025 78.5,22.1 v1(83.475,22.1) ; v1(66.65,28.5) 66.65,27.825 66.95,27.525 68,27.525 68.5,27.025 74.3,27.025 74.925,27.65 v1(83.8,27.65) ; v1(86.85,37.475) 97.365,37.475 v1(102.72,32.12)
  Signal Layer 4 w0.1: v1(83.475,22.1) 83.8,22.425 v1(83.8,27.65) 83.8,32.5 83.65,32.65 83.65,34.05 84.905,35.305 85.045,35.305 86.85,37.11 v1(86.85,37.475)
EXP_HEADER13: P101.13
EXP_HEADER14: J101.9 P101.14 U1.13 U812.4 | length 99.4
  Top Layer w0.1: U812.4@67.5,29.165 67.5,28.5 v1(68,28) ; v1(87.35,38.18) 87.6,37.93 U1.13@87.6,36 ; v1(102.47,33.81) P101.14@104.57,33.81
  Signal Layer 3 w0.1: J101.9@51.27,3.262 52.55,4.542 56.608,8.6 60.308,12.3 67.04,12.3 77.79,23.05 83.85,23.05 v1(84.8,22.1) ; v1(68,28) 69.275,28 69.975,27.3 74.175,27.3 75.05,28.175 82.575,28.175 82.9,28.5 v1(84.2,28.5) ; v1(87.35,38.18) 97.295,38.18 101.665,33.81 v1(102.47,33.81)
  Signal Layer 4 w0.1: v1(84.8,22.1) 84.2,22.7 v1(84.2,28.5) 84.2,32.34 84.575,32.715 84.575,34.505 87.35,37.28 v1(87.35,38.18)
EXP_HEADER15: J102.11 P101.15 R109.2 U1.7 U102.6 | length 107.3
  Top Layer w0.1: U1.7@86.6,33.7 86.6,32.6 86.675,32.525 v1(87.35,32.525) ; v1(106.7,36.4) P101.15@108.8,36.4 ; v1(106.85,51.425) R109.2@106.85,50.95 107.35,50.95 107.775,50.525 109.675,50.525 110.45,51.3 U102.6@110.45,51.5
  Signal Layer 3 w0.1: J102.11@56.35,56.602 56.35,56.71 58.14,58.5 70.3,58.5 71.325,57.475 v1(86.725,57.475) ; v1(87.35,32.525) 93.275,32.525 94.75,31.05 103.475,31.05 106.7,34.275 v1(106.7,36.4)
  Signal Layer 4 w0.1: v1(86.725,57.475) 86.725,56.7 87.225,56.2 87.225,54.135 89.68,51.68 89.68,37.755 88.81,36.885 88.81,34.91 89.1,34.62 89.1,34.275 v1(87.35,32.525) ; v1(106.7,36.4) 108.125,37.825 108.125,43.95 106.85,45.225 v1(106.85,51.425)
EXP_HEADER16: J102.12 P101.16 R108.2 U1.8 U102.1 | length 101.8
  Top Layer w0.1: U1.8@87.1,33.7 87.1,33.5 87.2,33.4 87.3,33.3 88.91,33.3 v1(88.97,33.36) ; v1(102.47,36.35) P101.16@104.57,36.35 ; v1(105.9,48.6) 105.95,48.6 R108.2@106.85,49.5 107.475,49.5 107.85,49.875 109.375,49.875 110.45,48.8 U102.1@110.45,48.6
  Signal Layer 3 w0.1: J102.12@58.89,56.602 60.188,57.9 69.7,57.9 72.35,55.25 87.5,55.25 87.72,55.47 v1(88.23,55.47) ; v1(88.97,33.36) 89.53,32.8 93.5,32.8 94.875,31.425 103.05,31.425 103.6,31.975 103.6,35.22 v1(102.47,36.35)
  Signal Layer 4 w0.1: v1(88.23,55.47) 87.7,54.94 87.7,54.15 89.9,51.95 89.9,37.575 89.04,36.715 89.04,35.01 89.32,34.73 89.32,33.71 v1(88.97,33.36) ; v1(102.47,36.35) 105.05,36.35 107.3,38.6 107.3,43.525 105.9,44.925 v1(105.9,48.6)
GND: C1.2 C2.2 C3.2 C4.2 C8.2 C102.2 C104.2 C106.2 C110.2 C143.2 C144.2 C600.2 C602.2 C607.2 C608.2 C609.2 C610.2 C611.2 C621.2 C625.2 C632.2 C635.2 C638.2 C641.2 C652.2 C653.2 C655.2 C660.2 C700.2 C701.2 C702.2 C703.2 C705.2 C706.2 C707.2 C708.2 C714.2 C720.2 C724.2 C728.2 C729.2 C730.2 C731.2 C761.2 C762.2 C800.2 C803.2 C804.2 C805.2 C806.2 C807.2 C808.2 C809.2 C810.2 C827.2 C828.2 C860.2 C861.2 C862.2 C863.2 C864.2 C865.2 C866.2 C867.2 C900.2 C901.2 C902.2 C903.2 C904.2 C905.2 C906.2 C907.2 C908.2 C909.2 C910.2 C911.2 C914.2 C919.2 C921.2 C922.2 C924.2 C925.2 C926.2 C927.2 C950.2 C951.2 D600.2 D703.2 D800.6 D801.7 D805.7 D806.2 D807.2 D808.2 D809.2 D903.1 J101.2 J101.15 J102.2 J102.15 LED100.2 LED900.2 M1.1 P100.1 P100.2 P101.1 P601.25@1.8,56.82 P601.26@1.8,48.18 P601.27@6.2,56.525 P601.27@6.85,56.82 P601.28@6.2,48.475 P601.28@6.85,48.18 P601.A1 P601.A12 P601.B1 P601.B12 P700.2 P800.3 P800.5 P800.9 P800.15 P800.17 P800.19 P801.7 P801.9 P801.11 P801.13 P801.15 Q100.1 Q100.4 Q100.5 Q807.1 Q807.4 R6.1 R7.1 R104.2 R113.1 R124.1 R125.1 R126.1 R127.1 R140.1 R141.1 R146.1 R602.1 R620.1 R621.1 R623.1 R628.2 R631.1 R634.1 R637.1 R640.1 R674.2 R688.2 R691.2 R703.1 R705.1 R706.1 R707.1 R708.1 R718.1 R760.1 R763.1 R767.1 R771.1 R792.1 R794.2 R814.1 R839.1 R850.1 R851.1 R852.1 R853.1 R930.2 R931.2 R950.2 R981.2 ST701.1 TPJ614.1 TPJ913.1 U1.3 U1.11 U1.17 U100.2 U102.2 U600.3 U600.9 U603.A1 U606.2 U622.2 U700.2 U700.5 U701.3 U701.9 U702.7 U703.3 U703.5 U703.9 U704.4 U800.7 U802.7 U803.B1 U803.D1 U803.D2 U804.B1 U804.D1 U805.7 U806.7 U808.2 U808.11 U808.12 U808.13 U808.14 U808.15 U808.16 U808.22 U808.25 U809.D1 U810.7 U812.7 U860.2 U861.2 U862.2 U863.2 U900.C5 U900.C8 U900.H3 U900.J3 U900.K11 U900.K12 U900.L5 U900.L6 U900.M8 U900.M11 U900.N8 U901.1 U901.2 U901.3 U901.4 U902.B2 U910.3 U950.7 X900.2 X900.4 | length 205.5
  Top Layer w0.1: 44.125,47.9 44.35,47.675 44.35,47.25 ; 44.85,46.674 44.85,46.275 v1@45.025,46.1
  Top Layer w0.15: D800.6@81.4,51.385 81.4,50.7 81.6,50.5 v1(81.6,50.425) ; D805.7@100.4,51.385 100.4,51.25 100.6,51.05 v1@101.05,51.05
  Top Layer w0.2: v1(39,30.5) 39.125,30.375 U100.2@39.775,30.375 ; v1(39.3,28.25) R141.1@39.8,28.25 ; C907.2@40.1,43.2 40.275,43.375 C924.2@41,43.375 C925.2@41.55,43.375 ; R705.1@40.4,36.8 v1(40.4,37.3) 40.5,37.3 40.9,36.9 R706.1@41,36.9 ; v1@41.725,47.5 41.75,47.475 R763.1@42.275,47.475 ; R140.1@41.8,32.1 v1(42.5,32.1) ; U702.7@42.5,37.56 v1(42.5,38.225) 42.65,38.225 43.475,39.05 C901.2@43.55,39.05 ; C104.2@42.725,30.2 43.1,29.825 v1(43.125,29.825) ; C144.2@42.725,30.75 v1(43.225,30.75) ; v1(43.975,31.75) 44.325,31.75 44.55,31.975 U603.A1@44.55,32.25 ; U900.K12@44.1,46 U900.K11@44.6,46 45,46 v1(45.025,46.025) v1@45.025,46.1 ; 44.35,47.25 U900.M11@44.6,47 44.85,46.75 44.85,46.674 ; R707.1@44.4,37.1 45.35,37.1 v1(45.425,37.175) ; 45.885,47.71 46.095,47.5 U900.N8@46.1,47.5 U900.M8@46.1,47 ; U900.C8@46.1,42.5 46.1,42.725 v1(46.35,42.975) ; v1(47.15,46) 47.1,46.05 U900.L6@47.1,46.5 U900.L5@47.6,46.5 ; U900.C5@47.6,42.5 47.6,42.65 v1@47.875,42.925 ; v1@48.224,45.25 v1(48.275,45.25) 48.3,45.25 v1@48.325,45.275 ; U900.H3@48.6,45 v1@48.325,45.275 ; U900.J3@48.6,45.5 48.375,45.275 v1@48.325,45.275 ; U901.2@50.4,50.25 49.875,50.25 v1(49.65,50.475) 49.925,50.75 U901.1@50.4,50.75 ; C911.2@50.925,44.375 C911.2@50.95,44.375 ; C911.2@50.925,44.4 C911.2@50.95,44.375 ; C909.2@51.125,43.55 50.975,43.7 50.975,44.35 C911.2@50.95,44.375 ; v1@51.225,39.45 51.275,39.45 U804.D1@51.825,38.9 ; v1@51.35,44.5 v1@51.35,44.45 ; U804.B1@51.825,37.9 52.525,37.9 v1(52.55,37.875) ; C804.2@51.9,36.1 52.375,36.1 v1(52.4,36.125) ; v1(52.025,39.75) 52.15,39.875 52.4,39.875 52.575,40.05 C810.2@52.575,40.3 ; U860.2@52.3,48 52.625,48 52.95,48.325 C862.2@53.05,48.325 53.35,48.325 53.6,48.075 v1@53.6,47.975 ; U950.7@52.34,44.7 52,44.7 51.83,44.53 51.48,44.53 v1(51.4,44.45) ; U809.D1@52.55,42.425 52.7,42.425 v1(52.925,42.65) ; U902.B2@53.4,34.5 53.4,35.05 53.575,35.225 C914.2@53.575,35.55 ; C914.2@53.575,35.6 C914.2@53.575,35.55 ; R146.1@53.775,31.3 v1(54.425,31.3) ; v1(54.025,36) C914.2@53.575,35.55 ; R950.2@54.9,44.05 v1@55.4,44.05 ; C950.2@54.9,45.825 55.4,46.325 v1@55.4,46.362 ; C951.2@55.175,51.1 55.55,51.1 v1(55.675,50.975) ; R981.2@55.35,43.225 55.35,43.937 v1(55.4,43.987) ; Q100.5@56.975,50 57.375,50 v1(57.625,50.25) 57.375,50.5 Q100.4@56.975,50.5 ; v1(57.65,49.5) Q100.1@58.275,49.5 ; v1(60.325,36.058) 60.558,35.825 U803.B1@60.9,35.825 ; U803.D1@60.9,34.825 60.9,34.5 61.15,34.25 61.4,34.5 U803.D2@61.4,34.825 ; U808.11@61.605,40.8 62.15,40.8 U808.25@62.65,41.3 ; v1(61.95,47.35) 62.075,47.225 C808.2@62.075,46.85 ; C860.2@62.4,37.1 62.45,37.15 U862.2@62.45,37.85 ; U808.12@62.65,40.255 U808.25@62.65,41.3 ; v1(63.425,44.55) 63.675,44.8 U808.22@65.195,44.8 ; U808.13@64.15,40.255 U808.25@64.15,41.3 ; C806.2@64.725,46.85 64.725,47.225 v1(64.85,47.35) ; R688.2@65.1,25.9 v1(65.1,26.425) ; U808.14@65.195,40.8 64.7,40.8 U808.25@64.2,41.3 ; U808.15@65.195,41.3 U808.25@64.2,41.3 ; U808.16@65.195,41.8 63.625,41.8 v1(63.4,41.575) ; U805.7@65.66,37.27 65.92,37.27 66.025,37.375 66.025,37.625 v1(66.05,37.65) ; v1(66.225,33.225) 66.35,33.225 C867.2@66.725,33.6 ; v1(66.65,38.6) C864.2@66.65,39.075 67.45,39.075 67.6,39.225 U861.2@67.6,39.55 ; C866.2@67.7,32.725 U863.2@67.7,33.45 ; v1(67.775,25.7) U622.2@68.45,25.7 ; U812.7@67.985,30.25 68.75,30.25 v1(68.8,30.3) ; v1(69.3,24.1) C653.2@69.3,24.625 ; R691.2@70,25.55 v1(70.675,25.55) ; C827.2@73.3,28.925 73.675,28.925 v1(73.8,28.8) ; C809.2@73.3,33.425 73.675,33.425 v1(73.8,33.3) ; C805.2@73.3,37.925 73.675,37.925 v1(73.8,37.8) ; C803.2@73.325,42.45 73.7,42.45 v1(73.825,42.325) ; v1(81.8,11.65) 81.826,11.65 R124.1@82.188,11.288 ; C106.2@83.206,12.306 83.206,11.794 v1(83.3,11.7) ; v1(83.807,13.657) 83.833,13.657 R127.1@84.195,13.295 ; C2.2@84.1,35.5 84.25,35.35 84.35,35.35 84.7,35 U1.3@85.062,35 ; v1(86.21,35.45) 86.21,35.39 U1.17@86.6,35 U1.11@87.896,35 ; v1(88.826,3.6) 88.826,3.626 R125.1@89.188,3.988 ; R113.1@90.282,5.082 90.308,5.082 v1(90.745,4.645) ; R126.1@91.588,6.388 91.95,6.026 v1(91.976,6.026) ; C8.2@104.1,15.075 104.1,15.6 v1(104.2,15.7) ; C911.2@50.95,44.375 50.993,44.375 51.068,44.45 v1@51.35,44.45 ; v1@51.35,44.45 51.35,44.399 v1(51.4,44.45) ; v1@51.35,44.45 v1(51.4,44.45) ; U808.25@62.65,41.3 62.925,41.575 v1(63.4,41.575) ; v1(63.4,41.575) 63.675,41.3 U808.25@64.15,41.3 ; U808.25@64.15,41.3 U808.25@64.2,41.3
  Top Layer w0.25: U703.5@27.45,40.65 v1@28.25,40.65 ; C702.2@30.825,33.4 30.85,33.375 U701.3@30.85,32.65 30.85,31.75 U701.9@31.1,31.5
  Top Layer w0.27: P601.B1@5.95,49.875 6.585,49.875 v1(6.61,49.85) ; P601.B12@5.95,55.375 6.655,55.375 v1(6.69,55.34) ; P601.A12@7.55,49.625 8.15,49.625 v1(8.375,49.4) ; P601.A1@7.55,55.125 7.55,55.5 7.625,55.575 v1(7.625,55.6) ; v1(15.95,7.95) R794.2@16.5,7.95 ; D801.7@76.2,51.385 76.2,51.05 76.55,50.7 v1(76.65,50.7)
  Top Layer w0.3: D600.2@10.675,52.375 11.225,52.375 v1(11.25,52.4) ; R621.1@12.2,51.825 12.2,51.9 v1(12.2,52.4) 12.2,52.9 R620.1@12.2,52.975 ; v1(12.475,3.625) D703.2@13.2,3.625 ; C600.2@12.5,54.725 12.525,54.7 U600.3@13.3,54.7 U600.9@14.2,54.7 ; v1(13.501,2.325) 13.6,2.424 13.6,2.825 R792.1@13.675,2.9 ; R602.1@17,53.4 17.15,53.25 v1(17.15,52.95) ; C602.2@17.075,54.7 17.525,54.7 v1(17.625,54.6) ; C610.2@21.475,26.675 21.475,27.2 R623.1@21.5,27.225 21.725,27.45 v1(21.975,27.45) 22.45,26.975 R628.2@22.45,26.875 ; v1(23.8,40.925) R767.1@23.8,41.75 ; C621.2@24.15,24.8 24.15,24.35 v1(24.2,24.3) ; U700.5@24.5,33.35 24.725,33.35 24.725,32.65 U700.2@24.75,32.625 24.75,31.875 C708.2@24.775,31.85 24.825,31.85 v1(25.2,31.475) ; C660.2@25.05,26.075 25.7,26.075 v1(25.8,25.975) ; v1(25.475,40.175) C728.2@26.05,40.175 ; U704.4@25.545,43.625 26.175,43.625 26.4,43.4 v1(26.5,43.4) ; R760.1@25.55,36.175 25.575,36.15 C701.2@26.1,36.15 26.1,36.65 26.2,36.75 v1(26.2,36.825) ; C706.2@26,6.975 v1(26.5,6.975) ; U606.2@26.9,26.625 26.9,26.025 v1(27.025,25.9) ; C700.2@27,36.55 v1(27.85,36.55) ; v1(27.05,46.475) C720.2@27.05,47.1 ; v1(28,46.5) 28.1,46.6 28.1,47.2 C731.2@28.3,47.4 ; v1(28.2,32.2) 28.2,32.225 C762.2@28.2,32.675 ; v1@28.25,40.65 v1(28.375,40.775) ; v1(28.6,46.5) C730.2@29.225,46.5 ; U703.9@28.85,39.625 28.9,39.675 U703.9@29.075,39.675 ; C761.2@29.1,31.75 29.375,31.475 v1(29.375,31.075) ; v1(29.3,28.6) 29.525,28.6 R703.1@29.775,28.85 ; v1(29.325,39.675) U703.9@29.075,39.675 ; v1(30.75,28.3) 30.875,28.425 C705.2@30.875,28.875 ; v1(30.8,49.8) 30.8,49.2 D903.1@30.85,49.15 ; R674.2@30.95,26.625 30.95,27.1 v1(31.05,27.2) 31.625,27.2 C625.2@31.9,27.475 ; R718.1@31.925,39.525 31.35,40.1 C729.2@31.025,40.1 30.975,40.15 U703.3@30.25,40.15 29.1,40.15 U703.9@28.85,39.9 U703.9@29.075,39.675 ; v1(32.6,45.975) C724.2@32.6,46.6 ; v1(39.35,43.2) C907.2@40.1,43.2 ; v1(39.55,49.3) C919.2@40.3,49.3 ; v1(39.975,46.075) C900.2@40.65,46.075 ; v1(40.475,39.65) 41.05,39.65 C902.2@41.225,39.825 ; v1(41.25,49.25) 41.5,49 C903.2@42.1,49 42.325,49.225 42.825,49.225 v1(42.875,49.275) 43.3,49.275 C905.2@43.375,49.35 ; v1(42.875,49.9) C906.2@43.375,49.9 ; C609.2@43.275,32.025 43.7,32.025 v1(43.975,31.75) ; C904.2@43.375,48.8 43.375,48.625 v1(43.8,48.2) 44,48 44.025,48 44.125,47.9 ; C707.2@43.425,34.95 43.8,34.95 v1(43.9,34.85) ; v1@43.925,34.85 v1(43.9,34.85) ; R708.1@44.4,35.175 44.225,35.175 v1(43.9,34.85) ; v1(44.6,34.5) 44.6,34.6 C922.2@44.95,34.95 45.025,35.025 U910.3@46.225,35.025 47.625,35.025 v1(47.8,35.2) ; v1(44.775,39.45) 44.775,39.325 44.975,39.125 C927.2@45.325,39.125 ; X900.4@45,50.2 v1(45,50.975) ; P100.1@45.25,30.175 45.25,30.95 v1(45.475,31.175) ; v1@45.675,48.05 45.675,48.325 46.4,49.051 X900.2@46.4,49.1 ; v1(45.675,48.05) 45.675,47.92 45.885,47.71 ; P100.2@45.75,30.175 45.75,30.9 ; C143.2@46.2,31.25 45.75,31.25 ; R637.1@46.65,32.2 46.625,32.225 C638.2@46.1,32.225 45.7,32.225 C608.2@45.3,31.825 45.3,31.35 v1(45.475,31.175) ; v1@46.975,38.625 C926.2@46.975,39.125 ; C641.2@47.75,32.225 47.775,32.2 R640.1@48.3,32.2 v1(48.3,31.7) ; v1@47.825,35.225 v1(47.8,35.2) ; C910.2@48.125,48.8 48.125,49.275 v1(48.15,49.3) R930.2@48.15,49.8 R931.2@48.15,50.4 ; v1(48.2,34.075) 47.8,34.475 v1(47.8,35.2) ; C921.2@48.3,37.5 48.4,37.4 v1(48.4,36.7) ; C635.2@49.4,32.225 v1(49.4,31.725) 49.8,31.725 49.95,31.875 R634.1@49.95,32.2 ; C908.2@49.475,48.8 49.65,48.975 v1(49.65,49.4) ; v1(49.975,12.45) 50.275,12.45 C102.2@50.45,12.275 ; v1(50.225,13.15) R104.2@50.85,13.15 ; U901.4@50.4,49.25 49.8,49.25 v1(49.65,49.4) ; U901.3@50.4,49.75 50,49.75 v1(49.65,49.4) ; v1(50.675,46.95) 50.675,47.095 50.868,47.288 50.868,47.368 R850.1@50.9,47.4 51.133,47.4 51.483,47.05 C863.2@51.625,47.05 ; C632.2@51.05,32.225 51.575,32.225 R631.1@51.6,32.2 51.625,32.175 v1(51.625,31.7) ; C861.2@61.45,39.1 v1(61.45,39.65) ; U808.2@61.605,45.3 61.875,45.3 62.075,45.5 C808.2@62.075,46.85 ; C807.2@62.35,35.85 v1(62.725,35.475) C800.2@63.1,35.85 ; C860.2@62.4,37.1 62.825,37.1 v1(62.875,37.15) ; v1(62.45,30) Q807.4@63.125,30 ; U808.12@62.65,40.255 62.65,39.55 62.8,39.4 R852.1@62.8,39.25 ; Q807.1@64.425,29 64.425,28.25 R839.1@64.4,28.225 65.25,28.225 v1(65.4,28.375) C828.2@65.4,28.875 ; v1(66.1,41.275) 66.2,41.275 C865.2@66.65,40.825 ; R814.1@66.6,36.1 66.6,35.725 66.65,35.675 v1@66.65,35.6 ; v1(67.625,32.2) 67.7,32.275 C866.2@67.7,32.725 ; R851.1@68.2,40.9 68.675,40.9 v1(68.7,40.875) ; R853.1@68.375,34.825 68.4,34.85 68.678,34.85 ; v1(68.7,34.025) 68.7,34.822 68.675,34.847 68.678,34.85 ; v1(68.8,30.3) 68.85,30.35 U810.7@69.45,30.35 ; v1(69.275,44.4) 69.45,44.225 U800.7@69.45,43.85 ; U806.7@69.45,34.85 68.678,34.85 ; U802.7@69.45,39.35 v1(69.45,39.825) ; C3.2@82.2,37.8 v1(82.2,38.55) ; v1(82.35,35.4) C1.2@83.1,35.4 83.2,35.5 C2.2@84.1,35.5 ; C4.2@84.2,37.2 v1(84.2,37.85) ; v1(84.25,51.425) D809.2@84.25,52.1 ; R6.1@85,38.25 v1(85,38.9) ; LED900.2@87.25,56.45 v1(87.25,57) ; v1(95.075,51.35) 95.2,51.475 D806.2@95.2,52 ; v1(96.7,51.325) D807.2@96.7,52 ; v1(101.75,51.534) D808.2@101.75,52.209 ; R7.1@110.4,13.125 v1(110.4,13.775) ; v1@110.475,52.375 C110.2@110.975,52.375 ; v1(111.075,47.975) 111.075,48.225 U102.2@111.45,48.6 ; v1(45.475,31.175) 45.55,31.25 45.75,31.25 ; v1(45.475,31.175) 45.75,30.9 ; 45.75,30.9 45.75,31.25
  Top Layer w0.4: v1@61.8,23.425 C655.2@61.8,24.1 ; C652.2@66.3,24.1 v1@66.975,24.1 ; v1(67.73,13.87) 68.15,13.45 LED100.2@69,13.45
  Top Layer w0.5: C611.2@11.6,54.3 11.5,54.3 11.625,54.175 v1(11.625,53.6) ; v1(14.65,52.1) 14.8,52.25 C607.2@14.8,52.9 ; C714.2@25,38.55 v1(25,39.325) ; v1(31.925,38.75) R718.1@31.925,39.525 ; R771.1@32.2,42.6 32.875,43.275 v1(32.875,43.3) ; C703.2@41.25,34.5 41.25,35.175 41.3,35.225 v1(41.55,35.225) ; v1(97.55,56.325) 97.85,56.625 97.85,57.786 P801.7@97.905,57.841
  Top Layer w0.635: v1(72.765,56.325) 72.785,56.345 P800.19@72.785,57.95 ; v1(74.035,56.325) 74.055,56.345 P800.17@74.055,57.95 ; v1(75.305,56.325) 75.325,56.345 P800.15@75.325,57.95 ; v1(79.115,56.325) 79.135,56.345 P800.9@79.135,57.95 ; v1(81.655,56.325) 81.675,56.345 P800.5@81.675,57.95 ; v1(82.925,56.325) 82.945,56.345 P800.3@82.945,57.95 ; v1(92.81,56.325) 92.835,56.325 92.825,56.335 P801.15@92.825,57.841 ; v1(94.08,56.325) 94.105,56.325 94.095,56.335 P801.13@94.095,57.841 ; v1(95.35,56.325) 95.375,56.325 95.365,56.335 P801.11@95.365,57.841 ; v1@96.635,56.335 P801.9@96.635,57.841 ; v1(107.625,17.05) 107.625,18.25 107.945,18.57 P101.1@108.76,18.57 109.705,18.57 110,18.275 v1(110,17.425) v1(110,16.75) v1@110,16.725
  GND Layer 2 w0.3: v1(107.505,49.102) 107.5,49.108 107.5,49.35 108.25,50.1 110.475,50.1 ; v1@110.475,52.375 110.475,50.1 ; v1(111.075,47.975) 111.075,49.5 110.475,50.1
  Bottom Layer w0.3: v1(6.61,49.85) 6.666,49.85 6.716,49.8 TPJ614.1@7.55,49.8 7.975,49.8 v1(8.375,49.4) ; 88.55,31.4 v1(89.2,31.4) ; 89.15,28.65 v1(90.15,28.65)
  Bottom Layer w0.5: TPJ913.1@50.751,30.501 51.425,29.828 v1(51.425,29.575)
  other v1: 9.5,2 101,3 82.5,3.5 62.65,4.55 67.625,4.6 39.85,4.675 44.925,4.675 32.275,4.8 71.5,5 52.5,5.35 100.35,7 112.5,7.5 38.76,10.48 48.5,10.5 28,11 97.34,13.12 94.5,15.5 112.5,15.5 7,16 80.5,16 71.8,16.2 6,17 8,17 88.2,17.2 39.5,17.5 7,18 60.5,18.5 96.575,18.95 28,19 76.625,19.2 100.8,20.423 50.5,22 72.55,22.55 61.8,23.375 96.925,23.5 73,24 67.025,24.1 100,24.3 78,24.5 111.3,24.8 80.7,25.5 58.475,26.075 97.9,26.1 94.425,26.125 15,28 58.1,28.05 100.5,28.3 85.15,28.65 91.975,29.4 30.625,31.175 31.575,31.175 30.625,31.825 31.35,31.825 92.3,31.9 88.245,32.13 95.25,32.2 101.5,32.2 5,33 61.175,34.25 86.12,34.53 87.1,34.52 102.3,35 111.4,35 87.09,35.47 66.6,35.6 95.85,36.2 91.35,36.5 100.075,37.45 79.155,38.45 91.4,38.6 46.925,38.625 28.375,39.075 21,39.5 51.075,39.5 28.375,39.95 56.6,40.65 78.175,40.675 13,42 100.6,42.375 47.925,42.925 63.4,43 110.7,43.5 73.95,44.45 4,44.5 22.05,45.45 79,45.9 9.99,46 55.525,46.362 104.5,47 41.725,47.525 14,48 53.75,48.025 83.67,48.24 61.5,48.925 67.5,50 88.975,50.95 100.875,51.025 110.425,52.375 14.775,54.475 57.625,54.675 52.5,54.8 14.45,54.95 65.225,55.325 14.125,55.425 34.75,55.475 96.6,56.325 18.5,57 27.5,57 104,57.5 88.825,57.925
JS_A: R125.2 SW105.1 | length 1.5
  Top Layer w0.1: SW105.1@88.57,5.464 89.612,4.423 R125.2@89.612,4.412
JS_B: R126.2 SW105.3 | length 1.7
  Top Layer w0.1: SW105.3@90.586,7.48 91.253,6.812 R126.2@92.012,6.812
JS_C: R127.2 SW105.6 | length 1.6
  Top Layer w0.1: R127.2@84.612,13.712 85.53,12.795 SW105.6@85.53,12.536
JS_CEN: R113.2 SW105.2 | length 1.7
  Top Layer w0.1: SW105.2@89.578,6.472 90.332,5.718 R113.2@90.918,5.718
JS_D: R124.2 SW105.4 | length 1.6
  Top Layer w0.1: R124.2@82.612,11.712 83.514,10.81 SW105.4@83.514,10.52
LED_JLINK: LED901.2 TPJ912.1 U900.A7 | length 54
  Top Layer w0.1: v1(46.425,38.275) 46.425,38.864 46.643,39.082 46.643,40.007 46.525,40.125 46.525,40.575 46.6,40.65 U900.A7@46.6,41.5
  Top Layer w0.2: LED901.2@10.65,50.4 v1@11.25,50.4
  Signal Layer 3 w0.1: v1(11.45,50.4) 12.77,50.4 22.745,40.425 24.8,40.425 25.325,40.95 25.85,40.95 26.35,41.45 31.125,41.45 33.775,38.8 41.075,38.8 41.875,39.6 43.225,39.6 44.7,38.125 45.075,38.125 45.175,38.225 46.375,38.225 v1(46.425,38.275)
  Bottom Layer w0.1: v1(46.425,38.275) 46.425,38.75 46.775,39.1 48.35,39.1 48.925,38.525 48.925,36.051 TPJ912.1@50.751,34.225
LED_STATUS_G: LED904.3 U900.D13 | length 31.6
  Top Layer w0.1: v1(37.775,43.1) 37.775,42.225 38.375,41.625 39.425,41.625 39.975,42.175 40.7,42.175 41,42.475 41.8,42.475 42.325,43 U900.D13@43.6,43
  Top Layer w0.2: LED904.3@21.15,49.75 v1(21.85,49.75)
  Signal Layer 3 w0.1: v1(21.85,49.75) 20.3,48.2 20.3,45.525 21.825,44 36.875,44 v1(37.775,43.1)
LED_STATUS_R: LED904.4 U900.E13 | length 28.7
  Top Layer w0.1: v1(38.45,43.125) 38.95,42.625 40.55,42.625 40.85,42.925 41.65,42.925 42.225,43.5 U900.E13@43.6,43.5
  Top Layer w0.2: LED904.4@21.15,49.05 v1(21.85,49.05)
  Signal Layer 3 w0.1: v1(21.85,49.05) 20.85,48.05 20.85,45.95 22.4,44.4 37.175,44.4 v1(38.45,43.125)
MCU_P0.0: J101.14 R5.2 R311.2 U1.2 | length 49
  Top Layer w0.1: J101.14@63.97,3.262 65.05,4.342 v1(65.05,6.58) 65.001,6.629 64.021,6.629 R311.2@64,6.65 ; R5.2@84.225,36.35 84.225,36.33 84.399,36.156 84.419,36.156 85,35.575 85.225,35.575 U1.2@85.3,35.5 ; R5.2@84.225,36.375 84.6,36.375 v1(84.9,36.675)
  Signal Layer 3 w0.1: v1(65.05,6.58) 68.605,6.58 80.575,18.55 v1(82.05,18.55)
  Signal Layer 4 w0.1: v1(82.05,18.55) 81.675,18.925 81.675,34.05 84,36.375 84.6,36.375 v1(84.9,36.675)
MCU_P0.1: J101.13 R6.2 R300.1 U1.1 | length 54
  Top Layer w0.1: J101.13@61.43,3.262 61.43,5.72 R300.1@61.4,5.75 v1(62.6,5.75) ; U1.1@85.6,36 85.375,36.225 85.375,36.975 R6.2@85,37.35 85.75,38.1 v1@85.75,38.5
  Signal Layer 3 w0.1: v1(62.6,5.75) 63.95,7.1 67.925,7.1 80.075,19.25 v1@82.625,19.25
  Signal Layer 4 w0.1: v1(82.625,19.275) 81.96,19.94 81.96,33.835 84.225,36.1 84.9,36.1 85.4,36.6 85.4,38.35 v1(85.75,38.7)
MCU_P0.3: J101.11 R135.2 R307.1 U1.15 | length 75.5
  Top Layer w0.1: R135.2@70.08,13.16 70.775,13.16 70.832,13.102 v1(71.527,13.102) ; v1(86.35,38.18) 86.35,37.01 86.6,36.76 U1.15@86.6,36.3 ; v1(99.57,22.83) 99.61,22.79 R307.1@100.32,22.79
  Signal Layer 3 w0.1: J101.11@56.35,3.262 57.8,4.712 63.188,10.1 68.525,10.1 78.875,20.45 95.94,20.45 98.32,22.83 v1(99.57,22.83)
  Signal Layer 4 w0.1: v1(83.51,20.45) 82.54,21.42 82.54,33.465 84.655,35.58 85.01,35.58 86.35,36.92 v1(86.35,38.18)
MCU_P2.0: J102.14 R303.2 R304.1 | length 20.6
  Top Layer w0.1: R303.2@48.65,51.5 50,52.85 v1(50,54.2) ; J102.14@63.97,56.602 63.97,54.28 R304.1@64,54.25
  Signal Layer 3 w0.1: v1(50,54.2) 51.2,55.4 62.768,55.4 J102.14@63.97,56.602
N16809528: D703.1 P700.1 Q703.3 ST701.2 | length 60.2
  Top Layer w0.5: ST701.2@2.875,4.62 3.82,4.62 v1@4.087,4.887 ; v1(4.087,4.981) v1@4.087,4.887 ; P700.1@7,6.078 5.278,6.078 v1@4.087,4.887 ; v1(10.046,4.981) 12.019,4.981 12.675,4.325 D703.1@13.2,4.325 14.525,4.325 14.8,4.6 Q703.3@14.8,5.325
  Top Layer w1: P700.1@5.947,5.025 P700.1@7,6.078
  Signal Layer 4 w0.6: v1(3.958,7.181) 3.958,4.988 3.962,4.984 3.962,4.981 v1(4.087,4.981) v1(10.046,4.981) v1(10.046,6.081) v1(10.046,7.181) 11.714,7.181 17.039,12.506 17.039,20.919 11.133,26.825 v1(10.046,26.825) v1(10.046,27.925) 10.046,29.025 v1(3.958,29.025) 3.958,29.023 3.962,29.019 v1(3.962,27.925) v1(3.962,26.825)
  other v1: 3.962,6.081
N16809565: Q703.2 SW704.6 TP156.1 | length 5.4
  Top Layer w0.5: Q703.2@15.3,3.65 Q703.2@15.325,3.625
  Top Layer w0.635: Q703.2@15.325,3.625 v1(15.8,3.625) 17.15,3.625 18.4,2.375 SW704.6@18.4,1.75
  Bottom Layer w0.3: TP156.1@15.3,4.6 15.8,4.1 v1(15.8,3.625)
N16809744: R793.1 SW704.1 | length 2.1
  Top Layer w0.1: SW704.1@23.4,7.25 23.4,8 R793.1@24.7,8
N16809746: R794.1 SW704.3 | length 2
  Top Layer w0.1: R794.1@17.1,7.95 18.4,7.95 SW704.3@18.4,7.25
N16812963: Q703.1 R792.2 | length 0.8
  Top Layer w0.1: R792.2@14.275,2.9 14.3,2.925 Q703.1@14.3,3.65
N16831167: R700.1 U701.7 | length 0.9
  Top Layer w0.1: U701.7@31.35,30.35 31.35,29.525 R700.1@31.425,29.45
N16831188: C705.1 U701.6 | length 0.9
  Top Layer w0.1: U701.6@30.85,30.35 30.85,29.45 C705.1@30.875,29.425
N16831199: R702.1 R703.2 U701.5 | length 1.5
  Top Layer w0.1: R703.2@29.775,29.45 R702.1@30.325,29.45 30.35,29.475 U701.5@30.35,30.35
N16831281: R705.2 TP711.1 U702.11 | length 3.4
  Top Layer w0.1: v1(39.75,35.875) 40.075,35.875 R705.2@40.4,36.2 40.475,36.275 U702.11@41.815,36.275
  Bottom Layer w0.1: TP711.1@39.7,34.7 39.75,34.75 v1(39.75,35.875)
N16831285: R706.2 TP712.1 U702.8 | length 2.7
  Top Layer w0.1: v1(40.5,38) R706.2@41,37.5 41.025,37.475 U702.8@41.815,37.475
  Bottom Layer w0.1: TP712.1@39.7,38.8 v1(40.5,38)
N16831289: R707.2 TP713.1 U702.3 | length 2.7
  Top Layer w0.1: U702.3@43.585,36.675 44.225,36.675 R707.2@44.4,36.5 44.5,36.6 44.9,36.6 v1(44.95,36.65)
  Bottom Layer w0.1: TP713.1@43.8,36.7 43.85,36.65 v1(44.95,36.65)
N16831309: R708.2 TP714.1 U702.1 | length 2.8
  Top Layer w0.1: v1(43.625,35.475) 43.625,35.5 43.585,35.54 U702.1@43.585,35.875 44.3,35.875 R708.2@44.4,35.775
  Bottom Layer w0.1: TP714.1@43.2,34.1 43.2,35.05 v1(43.625,35.475)
N16831821: C707.1 L702.2 U702.14 | length 1.9
  Top Layer w0.2: C707.1@42.85,34.975 42.9,35.025 U702.14@42.9,35.79
  Top Layer w0.3: L702.2@42.435,34.05 42.85,34.465 C707.1@42.85,34.975
N16839091: R709.1 U703.1 U703.2 | length 3.3
  Top Layer w0.1: U703.2@30.25,39.65 30.825,39.65 30.95,39.525 30.95,39.325 30.775,39.15 U703.1@30.25,39.15 30.25,37.7 R709.1@30.35,37.6
N16839103: C710.2 U703.6 | length 0.8
  Top Layer w0.25: C710.2@26.65,40.175 26.675,40.15 U703.6@27.45,40.15
N16839111: C729.1 R718.2 U703.4 U704.3 U704.5 | length 9.5
  Top Layer w0.1: U704.3@25.545,44.275 27,44.275 27.65,43.625 U704.5@29.6,43.625 ; U704.5@29.756,43.625 U704.5@29.6,43.625 ; U703.4@30.225,40.675 U703.4@30.25,40.65 ; R718.2@31.925,40.925 31.3,40.925 C729.1@31.025,40.65 U703.4@30.25,40.65 ; U704.5@29.6,43.625 29.6,42 30.25,41.35 U703.4@30.25,40.65
N16839131: R710.1 U703.8 | length 2.6
  Top Layer w0.1: U703.8@27.45,39.15 27.45,38.775 27.775,38.45 28.3,38.45 R710.1@29.15,37.6
N16839143: L700.2 R717.1 | length 1
  Top Layer w0.5: L700.2@24.65,37.5 R717.1@25.6,37.5
N16839420: C766.1 R765.1 R767.2 U704.2 | length 3.1
  Top Layer w0.1: R767.2@23.8,43.15 R765.1@23.8,44.2 24.225,44.625 C766.1@24.7,44.625 25,44.925 U704.2@25.545,44.925
N16839426: C766.2 R764.1 R765.2 U704.1 | length 3.6
  Top Layer w0.1: R764.1@23.725,46.875 23.725,45.675 R765.2@23.8,45.6 24.225,45.175 C766.2@24.7,45.175 24.7,45.5 24.775,45.575 U704.1@25.545,45.575
N16839472: C770.1 R769.1 R771.2 U704.6 | length 3.5
  Top Layer w0.1: U704.6@29.756,44.275 30.475,44.275 C770.1@30.6,44.4 30.9,44.1 31.1,44.1 R769.1@31.5,43.7 31.2,43.4 31.2,43 R771.2@30.8,42.6
N16839478: C770.2 R768.1 R769.2 U704.7 | length 2.7
  Top Layer w0.1: U704.7@29.756,44.925 29.781,44.95 C770.2@30.6,44.95 R769.2@31.35,44.95 ; R769.2@31.5,45.1 R768.1@31.5,46.2
N16839586: C730.1 C731.1 R731.1 U704.8 | length 3.8
  Top Layer w0.5: R731.1@28.25,48.5 28.725,48.5 29.7,47.525 C731.1@29.7,47.4 29.755,47.345 29.755,45.631 U704.8@29.7,45.631
N16839602: L704.2 R731.2 | length 0.9
  Top Layer w0.5: L704.2@27.275,49.4 27.275,48.575 R731.2@27.35,48.5
N16846192: R808.2 U802.6 U802.12 U803.C1 U806.5 U806.6 U806.12 U806.13 | length 30.1
  Top Layer w0.1: v1(60.325,35.013) 60.638,35.325 U803.C1@60.9,35.325 ; U806.6@69.9,35.8 69.9,36.275 69.975,36.35 70.25,36.35 ; U802.6@69.9,40.3 69.912,40.312 69.912,40.912 v1(69.975,40.975) ; U806.5@70.4,35.8 70.4,36.2 70.25,36.35 ; v1@71.4,32.7 U806.12@71.4,33.4 ; U802.12@71.4,37.9 71.4,37.275 v1(71.275,37.15) 70.669,37.15 70.25,36.731 70.25,36.35 ; v1(71.5,32.625) R808.2@72.025,32.625 72.025,33 71.9,33.125 U806.13@71.9,33.4
  Signal Layer 3 w0.1: v1(60.325,35.013) 60.325,34.375 61.075,33.625 68.925,33.625 69.075,33.475 70.65,33.475 v1(71.5,32.625)
  Signal Layer 4 w0.1: v1(69.975,40.975) 71.275,39.675 v1(71.275,37.15) 70.6,37.15 70.25,36.8 70.25,35.7 71.5,34.45 v1(71.5,32.625)
N16846231: C804.1 C810.1 L801.2 U804.A2 U809.A2 | length 9.7
  Top Layer w0.2: U804.A2@51.325,37.4 51.325,37.15 51.825,36.65 C804.1@51.9,36.65 53.6,36.65 v1(53.65,36.7) ; v1(51.5,40.3) C810.1@52.025,40.3 52.05,40.325 U809.A2@52.05,40.925
  Top Layer w0.3: v1(53.65,36.7) L801.2@53.65,37.3
  Signal Layer 4 w0.25: 51.5,39.8 51.55,39.75 51.55,39.375 51.6,39.325
  Signal Layer 4 w0.3: 51.5,39.8 v1(51.5,40.3) ; 51.6,39.325 51.9,39.025 51.9,37.325 52.525,36.7 v1(53.65,36.7)
N16846319: Q800.1 U806.10 | length 9.8
  Top Layer w0.1: Q800.1@68.325,37.95 v1@68.325,38.625 ; v1(69.15,32.175) 69.425,32.175 70.4,33.15 U806.10@70.4,33.4
  Signal Layer 4 w0.1: v1@68.375,38.625 67.925,38.175 67.925,33.206 68.956,32.175 v1(69.15,32.175)
  other v1: 68.35,38.625
N16846537: RP801.5 U808.21 | length 1.1
  Top Layer w0.1: U808.21@65.195,44.3 RP801.5@66.25,44.3
N16846539: RP801.6 U808.20 | length 1.1
  Top Layer w0.1: U808.20@65.195,43.8 RP801.6@66.25,43.8
N16846547: RP801.7 U808.19 | length 1.1
  Top Layer w0.1: U808.19@65.195,43.3 RP801.7@66.25,43.3
N16846551: RP801.8 U808.18 | length 1.1
  Top Layer w0.1: U808.18@65.195,42.8 RP801.8@66.25,42.8
N16846567: Q800.2 R815.1 | length 1.8
  Top Layer w0.1: R815.1@66.6,38.05 66.6,38 67.15,37.45 67.5,37.45 67.825,37.775 Q800.2@67.825,37.95
N16846723: R805.1 U808.17 | length 1.3
  Top Layer w0.1: U808.17@65.195,42.3 66.05,42.3 R805.1@66.4,41.95
N16846896: RP800.8 U809.C1 | length 3.9
  Top Layer w0.1: U809.C1@52.55,41.925 v1@52.975,41.925 ; v1(53.525,39.65) RP800.8@54.1,39.65
  Signal Layer 4 w0.1: v1(53,42) 53.925,41.075 53.925,40.05 v1(53.525,39.65)
N16846900: RP800.6 U809.C2 | length 4.8
  Top Layer w0.1: v1(51.575,42.75) 51.575,42.4 U809.C2@52.05,41.925 ; v1(53.525,40.65) RP800.6@54.1,40.65
  Signal Layer 4 w0.1: v1(51.575,42.75) 52.45,41.875 52.45,41.15 52.95,40.65 v1(53.525,40.65)
N16846924: RP800.5 U804.C1 | length 4.2
  Top Layer w0.1: U804.C1@51.825,38.4 52.125,38.4 53.125,39.4 53.125,40.8 53.132,40.807 53.132,40.813 53.362,41.043 53.993,41.043 RP800.5@54.1,41.15
N16847739: U805.10 U806.9 | length 13.9
  Top Layer w0.1: U805.10@64.775,37.955 64.775,38.55 v1(65,38.775) ; v1(69.425,32.8) 69.9,33.275 U806.9@69.9,33.4
  Bottom Layer w0.1: v1(65,38.775) 64.2,37.975 64.2,36.2 63.75,35.75 63.75,35.2 64.025,34.925 69.15,34.925 69.9,34.175 69.9,33.275 v1(69.425,32.8)
N16847741: U805.9 U806.3 | length 8.1
  Top Layer w0.1: U805.9@65.175,37.955 65.175,38.25 65.4,38.475 65.975,38.475 v1(66.05,38.4) ; v1(71.275,36.5) 71.4,36.375 U806.3@71.4,35.8
  Signal Layer 3 w0.1: v1(66.05,38.4) 66.55,37.9 69.881,37.9 71.275,36.506 v1(71.275,36.5)
N16847743: U802.10 U805.4 | length 6.7
  Top Layer w0.1: U805.4@65.175,36.185 65.175,35.925 65.6,35.5 v1(65.825,35.5) ; v1(68.775,37.3) 68.875,37.4 69.776,37.4 70.024,37.4 70.4,37.776 U802.10@70.4,37.9
  Bottom Layer w0.1: v1(65.825,35.5) 67.075,36.75 68.225,36.75 v1(68.775,37.3)
N16847749: U802.9 U805.2 | length 7.7
  Top Layer w0.1: U805.2@64.375,36.185 64.375,35.945 v1@64.795,35.525 ; v1@69,38.3 v1(69.175,38.3) 69.575,37.9 U802.9@69.9,37.9
  Bottom Layer w0.1: v1(64.975,35.491) 64.975,36.3 65.75,37.075 67.375,37.075 68,37.7 68.575,37.7 v1(69.175,38.3)
N16847975: R810.1 U804.C2 | length 3.7
  Top Layer w0.1: v1(50.85,38.388) 50.863,38.4 U804.C2@51.325,38.4 ; R810.1@53.25,38.725 53.3,38.675 v1(53.3,38.1)
  Signal Layer 3 w0.1: v1(50.85,38.388) 53.038,38.388 53.325,38.1 v1(53.3,38.1)
N16916520: U810.1 U812.1 U860.4 | length 43
  Top Layer w0.1: v1(51.553,48.752) 51.553,48.397 U860.4@51.6,48.35 ; v1(66.025,28.5) 66.025,28.625 66.3,28.9 U812.1@66.3,29.165 ; U810.1@72.35,30.35 72.375,30.375 72.55,30.375 72.6,30.425 v1(72.6,30.825)
  Signal Layer 3 w0.1: v1(51.553,48.752) 51.625,48.825 55.425,48.825 57.325,46.925 64.775,46.925 v1(66.05,45.65) ; v1(66.3,31.725) 66.668,31.357 68.524,31.357 68.807,31.074 68.807,31.062 69.037,30.832 69.049,30.832 69.056,30.825 v1(72.6,30.825)
  Signal Layer 4 w0.1: v1(66.025,28.5) 66.3,28.775 v1(66.3,31.725) 66.287,31.738 66.287,32.462 67.05,33.225 67.05,36.05 65.625,37.475 65.625,39.675 65.35,39.95 65.35,44.95 v1(66.05,45.65)
N16916530: U810.4 U812.3 U861.4 | length 17.4
  Top Layer w0.1: v1(67.025,29.85) 67.1,29.775 U812.3@67.1,29.165 ; U861.4@67.95,40.25 68.425,40.25 v1@68.45,40.275 ; U810.4@70.9,31.3 70.9,31.875 70.95,31.925 v1(70.95,31.975)
  Signal Layer 4 w0.1: v1(68.375,40.275) 68.4,40.275 69.6,39.075 69.6,38.1 69.2,37.7 69.2,36.65 69.725,36.125 69.725,35.35 70.25,34.825 70.25,32.575 70.85,31.975 v1(70.95,31.975)
  Bottom Layer w0.1: v1(67.025,29.85) 67.025,30.6 68.15,31.725 69.35,31.725 69.675,32.05 69.675,32.25 69.875,32.45 70.325,32.45 70.8,31.975 v1(70.95,31.975)
N16916558: U810.11 U812.11 U863.4 | length 13.2
  Top Layer w0.1: U812.11@66.7,30.935 66.7,31.2 67.075,31.575 68.743,31.575 ; U863.4@68.05,34.15 68.05,34.025 68.3,33.775 68.3,33.7 68.7,33.3 v1(68.7,33.225) 68.743,33.182 68.743,31.575 ; v1@68.723,27.55 70.625,27.55 70.9,27.825 U810.11@70.9,28.9 ; v1(69.15,31.3) 69.125,31.3 68.85,31.575 68.743,31.575
  Signal Layer 4 w0.1: v1(68.725,27.55) 68.725,29.439 69.193,29.907 69.193,31.218 69.15,31.261 v1(69.15,31.3)
N16916616: U810.8 U812.8 U862.4 | length 15.5
  Top Layer w0.1: U862.4@62.8,38.55 v1(63.225,38.55) ; U812.8@67.9,30.935 68.36,30.935 v1(68.375,30.95) 68.493,30.832 69.693,30.832 69.95,30.575 69.95,30.125 69.675,29.85 U810.8@69.45,29.85
  Signal Layer 3 w0.1: v1(63.9,31.975) 65.2,31.975 66.225,30.95 v1(68.375,30.95)
  Signal Layer 4 w0.1: v1(63.225,38.55) 63.225,37.525 64,36.75 64,35.95 63.875,35.825 v1@63.875,31.975
N16917071: R882.1 U860.3 | length 2.8
  Top Layer w0.1: U860.3@52.3,48.35 52.45,48.35 52.775,48.675 54.575,48.675 R882.1@54.85,48.4
N16922979: R601.1 R602.2 U600.5 | length 1.5
  Top Layer w0.25: U600.5@15.6,54.2 16.2,54.2 R601.1@16.4,54
  Top Layer w0.3: R601.1@16.4,54 R602.2@17,54